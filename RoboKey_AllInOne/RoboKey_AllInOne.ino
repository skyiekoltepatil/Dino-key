/*
  DINO KEY V1 — All-In-One ESP32-C3 + 1.3" SH1106 OLED Firmware
  Board: XIAO ESP32-C3 / ESP32C3 Dev Module (USB CDC On Boot: Enabled)
  Libs:  U8g2, RTClib, Adafruit MAX1704X
*/

#include <Arduino.h>
#include <Wire.h>
#include <U8g2lib.h>
#include <RTClib.h>
#include <Adafruit_MAX1704X.h>
#include <WiFi.h>
#include <WebServer.h>
#include <DNSServer.h>
#include <ESPmDNS.h>
#include <Preferences.h>
#include <NimBLEDevice.h>
#include <NimBLEHIDDevice.h>
#if defined(CONFIG_NIMBLE_CPP_IDF)
#include "services/gatt/ble_svc_gatt.h"
#else
#include "nimble/nimble/host/services/gatt/include/services/gatt/ble_svc_gatt.h"
#endif
#include <time.h>

#define BOOT_TITLE          "DINO KEY"
#define BOOT_OWNER          "ANAGH KOLTE"
#define BOOT_VERSION        "v1.0"
#define OLED_ROTATION       U8G2_R2
#define PIN_SDA             6
#define PIN_SCL             7
#define PIN_INPUT           3
#define INPUT_AUTO_DETECT   true
#define USE_TOUCH_SENSOR    false
#define AP_SSID             "DINO-KEY"
#define BLE_NAME            "DINO KEY"
#define ENABLE_WIFI_NTP     1
#define DEFAULT_12H_FORMAT  true
#define DINO_BLE_SERVICE_UUID "4fafc201-1fb5-459e-8fcc-c5c9c331914b"
#define DINO_BLE_CHAR_UUID    "beb5483e-36e1-4688-b7f5-ea07361b26a8"

const char* WIFI_SSID = "YourWiFiName";
const char* WIFI_PASS = "YourWiFiPassword";
const int32_t DEFAULT_TZ_MIN = 330;
const uint32_t AUTO_SLEEP_MS = 180000UL;
const uint8_t BRIGHTNESS_VALS[5] = {15, 60, 120, 190, 255};

U8G2_SH1106_128X64_NONAME_F_HW_I2C u8g2(OLED_ROTATION, U8X8_PIN_NONE, PIN_SCL, PIN_SDA);
RTC_DS3231 rtc;
Adafruit_MAX17048 maxlipo;
WebServer server(80);
DNSServer dnsServer;
Preferences prefs;

enum ScreenMode { MODE_HOME = 0, MODE_CLOCK, MODE_STOPWATCH, MODE_BATTERY, MODE_DINO, MODE_FULL_FACE, MODE_CONNECT, MODE_BRIGHTNESS, MODE_SLEEP };
enum InputEvent { EVT_NONE, EVT_PRESS_DOWN, EVT_SINGLE_CLICK, EVT_DOUBLE_CLICK, EVT_LONG_PRESS };
enum WifiStaState { STA_IDLE, STA_CONNECTING, STA_CONNECTED, STA_COOLDOWN };
enum BleCtsState {
  CTS_IDLE = 0, CTS_WAIT_SEC, CTS_DISC_SVC, CTS_DISC_SVC_WAIT, CTS_DISC_CHR, CTS_DISC_CHR_WAIT,
  CTS_READ_LOCAL, CTS_READ_LOCAL_WAIT, CTS_READ_TIME, CTS_READ_TIME_WAIT,
  CTS_DISC_BAT_SVC, CTS_DISC_BAT_SVC_WAIT, CTS_DISC_BAT_CHR, CTS_DISC_BAT_CHR_WAIT,
  CTS_READ_BAT, CTS_READ_BAT_WAIT, CTS_DONE
};
struct DinoCactus { float x; int w, h; };

RTC_DATA_ATTR uint32_t dinoBest = 0, softEpochSaved = 0, softBuildTag = 0;

bool rtcAvailable = false, ntpSynced = false, batteryAvailable = false, critFlash = false;
bool swRunning = false, isBlinking = false, timeSyncedLive = false, sntpStarted = false;
bool touchActiveHigh = USE_TOUCH_SENSOR, dinoPlaying = false, bleHostBatValid = false, bleHostBatCharging = false;
bool bleCtsSecStarted = false;

float batPercent = 88.0f, batVoltage = 4.02f, batChargeRate = 0.0f, bleHostBatPct = 0.0f;
float dinoY = 0, dinoVy = 0, dinoDist = 0, groundShift = 0;
uint32_t swAccumMs = 0, dinoScore = 0, dinoOverAt = 0, dinoLastFrame = 0;
unsigned long lastBatPoll = 0, lastRtcPoll = 0, lastFrameMs = 0, lastActivityMs = 0, critFlashMs = 0;
unsigned long swStartMs = 0, nextBlinkMs = 3000, blinkEndMs = 0, lastSoftTickMs = 0, lastHwRetryMs = 0, lastNvsSaveMs = 0;
unsigned long wifiStateMs = 0, staConnectedAtMs = 0, lastHttpTimeTryMs = 0, lastNtpSyncMs = 0;
unsigned long bleConnAtMs = 0, bleNextCtsProbeMs = 0, bleNextBatPollMs = 0;

int faceIdx = 1, wifiActiveSlot = 0;
uint8_t brightnessLevel = 5, lastBleBatSent = 100;
int32_t tzOffsetMin = DEFAULT_TZ_MIN;
ScreenMode currentMode = MODE_HOME, previousMode = MODE_HOME;
WifiStaState wifiState = STA_IDLE;
DinoCactus cacti[2];
DateTime cachedNow(2026, 11, 26, 23, 0, 0);
String timeSource = "EST", wifiSsid1, wifiPass1, wifiSsid2, wifiPass2, activeStaSsid, lastWifiErr;

NimBLEServer* bleServer = nullptr;
NimBLEHIDDevice* bleHid = nullptr;
NimBLECharacteristic *bleHidInput = nullptr, *bleCmdChar = nullptr, *bleBatChar = nullptr;
NimBLEAdvertisementData bleAdvData, bleScanData;

volatile bool bleClientConnected = false, bleCmdPending = false, bleGotDirectCmd = false;
volatile bool bleCtsPending = false, bleCtsHasTz = false, bleCtsEncrypted = false;
volatile bool bleHostBatPending = false, bleSvcChangedPending = false;
volatile bool bleCtsLogAuth = false, bleCtsLogFound = false, bleCtsLogNoCts = false;
volatile uint16_t activeBleConnHandle = 0, bleCtsSvcStart = 0, bleCtsSvcEnd = 0, bleCtsTimeHandle = 0, bleCtsLocalHandle = 0;
volatile uint16_t bleBatSvcStart = 0, bleBatSvcEnd = 0, blePeerBatHandle = 0;
volatile uint32_t bleCtsLocalEpoch = 0;
volatile int32_t bleCtsTzMin = DEFAULT_TZ_MIN;
volatile uint8_t bleHostBatVal = 0, bleCtsAttempt = 0;
volatile int bleCtsLastErr = 0;
volatile BleCtsState bleCtsState = CTS_IDLE;
char bleCmdBuf[192] = {0};
portMUX_TYPE bleMux = portMUX_INITIALIZER_UNLOCKED;

static const uint8_t DINO_HID_REPORT_MAP[] = {
  0x05,0x0C,0x09,0x01,0xA1,0x01,0x85,0x01,0x15,0x00,0x25,0x01,0x75,0x01,
  0x95,0x03,0x09,0xCD,0x09,0xE9,0x09,0xEA,0x81,0x02,0x95,0x05,0x81,0x03,0xC0
};

const int FACE_SLEEPY_IDX = 5, FACE_SLEEPING_IDX = 6;
const int GROUND_Y = 56, DINO_X = 10, DINO_W = 11, DINO_H = 11;

const uint16_t HOME_OFFSETS[20] PROGMEM = { 0, 51, 122, 214, 275, 378, 407, 457, 550, 600, 635, 696, 771, 832, 922, 986, 1040, 1093, 1138, 1206 };
const uint16_t HOME_LENGTHS[20] PROGMEM = { 51, 71, 92, 61, 103, 29, 50, 93, 50, 35, 61, 75, 61, 90, 64, 54, 53, 45, 68, 70 };
const uint8_t  HOME_SPANS[3828] PROGMEM = {
  33,22,9,86,22,9,33,23,9,86,23,9,33,24,9,86,24,9,33,25,9,86,25,9,33,26,9,86,26,9,33,27,9,86,27,9,33,28,9,86,28,9,33,29,9,86,29,9,33,30,9,86,30,9,33,31,9,86,31,9,33,32,9,86,32,9,33,33,9,86,33,9,
  33,34,9,86,34,9,33,35,9,86,35,9,33,36,9,86,36,9,33,37,9,86,37,9,33,38,9,86,38,9,33,39,9,86,39,9,33,40,9,86,40,9,33,41,9,86,41,9,33,42,9,86,42,9,33,43,9,86,43,9,33,44,8,87,44,8,57,55,15,57,56,15,
  57,57,15,57,58,15,57,59,15,28,22,5,93,22,5,28,23,5,93,23,5,28,24,5,93,24,5,26,25,10,90,25,11,25,26,12,89,26,13,25,27,12,89,27,13,22,28,17,87,28,7,97,28,8,21,29,7,33,29,6,87,29,6,98,29,7,21,30,8,33,30,6,
  87,30,6,98,30,7,21,31,7,33,31,8,85,31,8,99,31,8,21,32,6,34,32,8,85,32,5,101,32,7,18,33,7,36,33,8,82,33,8,102,33,7,18,34,7,36,34,8,82,34,8,102,34,7,18,35,5,39,35,5,82,35,5,104,35,5,18,36,4,39,36,5,
  82,36,5,105,36,4,18,37,4,39,37,5,82,37,5,105,37,4,18,38,4,39,38,5,83,38,4,105,38,4,51,49,4,71,49,4,51,50,4,71,50,5,51,51,4,71,51,5,51,52,4,70,52,6,51,53,4,70,53,6,51,54,24,51,55,23,51,56,22,54,57,18,
  54,58,18,54,59,18,28,22,2,97,22,3,28,23,2,97,23,3,28,24,2,97,24,3,28,25,2,97,25,3,29,26,3,44,26,6,77,26,7,96,26,2,30,27,2,44,27,6,77,27,7,96,27,2,30,28,2,44,28,6,77,28,7,96,28,2,22,29,2,30,29,2,
  44,29,6,77,29,8,96,29,1,103,29,2,22,30,3,30,30,2,44,30,6,77,30,8,96,30,1,102,30,3,22,31,5,44,31,6,77,31,8,101,31,3,24,32,3,44,32,6,77,32,8,100,32,3,25,33,3,44,33,6,77,33,8,99,33,3,26,34,2,44,34,6,
  77,34,8,100,34,1,19,35,4,44,35,6,77,35,8,105,35,3,19,36,6,44,36,6,77,36,8,101,36,7,19,37,6,44,37,6,77,37,8,101,37,7,44,38,6,77,38,8,44,39,6,77,39,8,44,40,6,77,40,8,44,41,6,77,41,8,44,42,6,78,42,7,
  55,46,18,55,47,19,55,48,19,55,49,3,70,49,4,55,50,3,70,50,4,55,51,3,70,51,4,55,52,3,70,52,4,55,53,3,70,53,3,57,54,4,67,54,4,57,55,4,67,55,4,58,56,3,67,56,4,60,57,8,60,58,8,61,59,7,29,22,1,31,22,6,
  92,22,6,29,23,9,92,23,7,29,24,9,92,24,7,29,25,9,92,25,7,29,26,9,89,26,10,29,27,9,89,27,6,29,28,9,88,28,7,29,29,9,86,29,6,29,30,9,85,30,7,29,31,9,82,31,10,29,32,9,82,32,7,29,33,9,82,33,7,29,34,9,
  82,34,7,29,35,9,82,35,9,29,36,9,85,36,7,29,37,9,85,37,9,29,38,9,88,38,7,29,39,9,89,39,7,29,40,9,89,40,9,29,41,9,89,41,9,29,42,9,92,42,6,29,43,9,92,43,7,29,44,9,92,44,7,52,50,5,69,50,4,52,51,5,
  68,51,5,52,52,5,68,52,5,52,53,5,68,53,5,52,54,21,54,55,17,54,56,16,56,57,13,56,58,13,56,59,13,38,22,4,86,22,5,38,23,4,86,23,5,38,24,5,86,24,6,35,25,10,83,25,11,35,26,10,83,26,11,35,27,4,40,27,8,81,27,6,
  91,27,6,32,28,7,42,28,6,80,28,7,91,28,6,32,29,7,42,29,6,80,29,7,91,29,6,13,30,3,32,30,4,43,30,8,78,30,6,94,30,6,112,30,4,13,31,5,29,31,6,46,31,5,77,31,7,94,31,6,111,31,5,14,32,4,29,32,6,47,32,4,
  77,32,6,95,32,5,111,32,4,15,33,4,29,33,4,47,33,4,77,33,5,96,33,4,110,33,4,16,34,4,29,34,4,48,34,3,77,34,4,96,34,4,109,34,4,18,35,2,29,35,4,48,35,3,78,35,3,97,35,3,110,35,1,11,36,3,30,36,3,49,36,2,
  114,36,3,11,37,5,113,37,4,11,38,5,113,38,4,110,39,2,16,40,4,109,40,4,16,41,4,109,41,4,15,42,5,110,42,5,13,43,5,112,43,4,13,44,4,54,44,21,112,44,4,14,45,2,54,45,21,113,45,2,54,46,21,54,47,21,54,48,4,71,48,4,
  54,49,4,71,49,4,54,50,4,71,50,4,54,51,4,71,51,4,54,52,4,71,52,4,54,53,7,68,53,6,57,54,4,68,54,4,57,55,4,68,55,4,58,56,14,60,57,9,60,58,9,60,59,9,84,22,7,97,22,3,84,23,7,96,23,3,85,24,6,95,24,3,
  87,25,3,94,25,3,87,26,2,94,26,6,85,27,3,93,27,7,84,28,7,84,29,8,84,30,8,28,43,18,66,43,18,28,44,18,66,44,19,28,45,18,66,45,19,28,46,18,66,46,19,27,47,19,66,47,19,51,56,10,51,57,10,51,58,10,51,59,10,88,22,5,
  99,22,3,78,23,7,90,23,3,98,23,3,78,24,7,90,24,2,97,24,3,81,25,3,89,25,3,96,25,3,80,26,3,87,26,3,95,26,4,79,27,3,87,27,6,95,27,7,78,28,3,87,28,6,96,28,6,78,29,7,78,30,7,26,40,3,43,40,3,66,40,3,
  82,40,3,26,41,3,43,41,3,66,41,3,82,41,4,26,42,3,43,42,3,66,42,3,82,42,4,26,43,4,42,43,4,66,43,4,82,43,4,26,44,20,66,44,20,26,45,19,66,45,19,29,46,14,69,46,14,29,47,14,69,47,14,51,56,10,51,57,10,51,58,10,
  51,59,10,28,22,2,98,22,3,28,23,2,98,23,3,28,24,2,98,24,3,28,25,2,98,25,3,28,26,4,96,26,3,29,27,3,44,27,7,78,27,8,96,27,3,30,28,2,44,28,7,78,28,8,96,28,2,30,29,2,44,29,7,78,29,8,96,29,2,104,29,2,
  30,30,2,44,30,7,78,30,8,96,30,2,103,30,3,44,31,7,78,31,8,102,31,2,44,32,7,78,32,8,100,32,4,44,33,7,78,33,8,100,33,2,44,34,7,78,34,8,100,34,2,19,35,6,44,35,7,78,35,8,106,35,3,19,36,6,44,36,7,78,36,8,
  105,36,4,19,37,9,44,37,7,78,37,8,102,37,5,22,38,6,44,38,7,78,38,8,102,38,4,25,39,3,44,39,7,78,39,8,102,39,2,25,40,3,44,40,7,78,40,8,102,40,2,44,41,7,78,41,8,44,42,7,78,42,7,61,45,7,60,46,8,58,47,3,
  68,47,3,58,48,3,68,48,3,58,49,3,68,49,3,58,50,3,68,50,3,58,51,3,68,51,3,58,52,3,68,52,3,58,53,3,68,53,3,58,54,3,68,54,3,58,55,3,68,55,3,58,56,3,68,56,3,61,57,8,61,58,7,61,59,7,86,22,10,86,23,2,
  93,23,3,86,24,2,93,24,3,92,25,4,90,26,6,89,27,5,89,28,5,89,29,3,90,30,2,32,32,7,69,32,6,32,33,7,69,33,6,90,33,2,32,34,7,69,34,6,89,34,3,32,35,7,69,35,6,90,35,2,32,36,7,69,36,6,32,37,7,69,37,6,
  32,38,7,69,38,6,32,39,7,69,39,6,32,40,7,69,40,6,32,41,7,69,41,6,32,42,7,69,42,6,32,43,7,69,43,6,32,44,7,69,44,6,32,45,7,69,45,6,32,46,7,69,46,6,32,47,7,69,47,6,49,56,9,49,57,9,49,58,9,49,59,9,
  86,22,3,92,22,4,99,22,3,86,23,3,92,23,4,99,23,3,86,24,3,93,24,3,99,24,3,26,37,20,68,37,18,26,38,20,68,38,18,26,39,20,68,39,18,26,40,20,68,40,18,26,41,20,68,41,18,40,42,6,68,42,3,83,42,3,40,43,6,68,43,3,
  83,43,3,40,44,5,68,44,3,61,52,4,61,53,4,60,54,5,60,55,5,51,56,14,51,57,12,51,58,12,51,59,12,37,22,4,87,22,4,36,23,5,86,23,6,36,24,5,86,24,6,36,25,5,86,25,6,36,26,5,86,26,6,36,27,5,86,27,6,36,28,5,
  86,28,6,34,29,7,86,29,6,93,29,1,33,30,8,86,30,9,33,31,8,86,31,9,33,32,8,86,32,9,33,33,8,86,33,9,32,34,9,86,34,10,18,35,23,89,35,20,18,36,20,90,36,19,18,37,20,90,37,19,18,38,20,90,38,19,18,39,16,94,39,15,
  18,40,16,94,40,15,18,41,16,94,41,15,55,47,17,55,48,17,55,49,17,55,50,17,51,51,25,51,52,25,51,53,9,67,53,9,51,54,7,70,54,6,51,55,5,70,55,6,51,56,5,71,56,5,51,57,5,71,57,5,51,58,5,71,58,5,51,59,4,71,59,5,
  15,22,30,81,22,32,15,23,30,81,23,32,14,24,31,81,24,32,14,25,31,81,25,32,14,26,31,81,26,32,14,27,31,81,27,32,15,28,30,81,28,32,15,29,29,82,29,30,23,30,9,96,30,8,23,31,9,96,31,8,24,32,8,96,32,7,27,33,5,96,33,4,
  27,34,5,96,34,4,27,35,5,96,35,7,23,36,9,96,36,8,23,37,9,96,37,8,23,38,9,96,38,8,23,39,9,96,39,8,23,40,9,96,40,8,23,41,9,96,41,8,23,42,9,96,42,8,23,43,9,96,43,8,23,44,9,96,44,8,23,45,9,97,45,7,
  23,46,9,100,46,3,24,47,8,24,48,8,96,48,7,27,49,5,96,49,7,27,50,5,96,50,7,24,51,8,96,51,8,23,52,8,96,52,8,23,53,8,96,53,8,23,54,7,96,54,8,23,55,7,96,55,8,23,56,7,96,56,8,23,57,6,96,57,8,23,58,6,
  96,58,8,24,59,5,97,59,6,92,22,3,97,22,2,91,23,4,97,23,4,89,24,5,98,24,4,90,25,3,99,25,3,89,28,5,98,28,4,91,29,4,96,29,6,92,30,3,96,30,3,93,31,2,96,31,3,26,32,5,77,32,4,93,32,2,97,32,2,26,33,5,
  77,33,5,26,34,7,75,34,7,26,35,8,73,35,9,28,36,7,72,36,8,28,37,9,70,37,9,31,38,6,70,38,7,31,39,7,69,39,8,31,40,11,67,40,10,31,41,11,67,41,10,31,42,11,67,42,10,31,43,7,69,43,8,31,44,6,70,44,7,31,45,6,
  70,45,7,31,46,6,70,46,7,31,47,6,70,47,7,32,48,5,72,48,5,49,54,9,49,55,9,49,56,9,46,57,5,55,57,6,46,58,3,58,58,3,46,59,3,58,59,3,37,24,8,83,24,8,37,25,8,83,25,8,37,26,8,83,26,8,37,27,8,83,27,8,
  37,28,8,83,28,8,37,29,8,83,29,8,37,30,8,83,30,8,37,31,8,83,31,8,37,32,8,83,32,8,37,33,8,83,33,8,37,34,8,83,34,8,37,35,8,83,35,8,37,36,8,83,36,8,37,37,8,83,37,8,37,38,8,83,38,8,37,39,8,83,39,8,
  37,40,8,83,40,8,37,41,8,83,41,8,37,42,8,83,42,8,37,43,8,83,43,8,37,44,8,83,44,8,37,45,8,83,45,8,38,46,7,83,46,8,15,47,4,26,47,4,105,47,4,115,47,4,15,48,4,26,48,4,105,48,4,115,48,4,14,49,5,25,49,5,
  103,49,6,114,49,5,13,50,6,24,50,6,102,50,7,113,50,6,13,51,5,24,51,5,102,51,5,113,51,4,12,52,5,22,52,6,101,52,6,111,52,6,11,53,5,22,53,4,100,53,5,111,53,5,9,54,6,20,54,6,98,54,7,109,54,6,9,55,5,19,55,6,
  98,55,5,109,55,4,9,56,4,19,56,5,98,56,5,109,56,4,9,57,4,19,57,5,98,57,5,109,57,4,96,22,2,101,22,3,95,23,5,101,23,3,95,24,9,95,25,9,97,26,6,98,27,4,99,28,2,99,29,1,27,30,5,36,30,5,72,30,6,82,30,5,
  27,31,6,36,31,6,72,31,6,81,31,6,27,32,6,36,32,6,70,32,9,81,32,8,24,33,10,35,33,9,69,33,21,24,34,21,69,34,21,24,35,21,69,35,21,24,36,21,69,36,21,24,37,21,69,37,21,24,38,21,69,38,21,27,39,15,72,39,15,27,40,15,
  72,40,15,27,41,15,72,41,15,30,42,9,75,42,9,30,43,9,75,43,9,31,44,7,75,44,9,32,45,4,78,45,3,32,46,4,78,46,3,48,51,3,63,51,4,47,52,4,63,52,4,47,53,4,63,53,4,47,54,5,63,54,4,47,55,20,48,56,18,51,57,13,
  51,58,13,51,59,7,28,22,72,27,23,73,27,24,73,27,25,73,27,26,73,32,27,27,70,27,26,32,28,27,70,28,26,32,29,27,70,29,26,33,30,26,70,30,25,35,31,21,72,31,21,35,32,21,72,32,21,36,33,18,75,33,16,38,34,16,75,34,16,38,35,16,
  75,35,16,103,37,1,102,38,2,102,39,3,70,40,2,101,40,5,69,41,4,100,41,6,69,42,4,99,42,3,104,42,5,56,43,3,68,43,5,97,43,5,105,43,4,56,44,3,67,44,5,99,44,4,104,44,4,57,45,14,101,45,5,58,46,12,101,46,5,59,47,11,
  102,47,2,59,48,10,102,48,2,102,49,2,17,57,94,17,58,94,17,59,12,45,59,7,32,22,5,66,22,2,89,22,6,32,23,2,66,23,2,92,23,3,32,24,2,64,24,4,93,24,2,32,25,2,64,25,2,67,25,1,93,25,2,32,26,2,62,26,6,93,26,2,
  62,27,4,67,27,1,60,28,6,60,29,6,60,30,6,58,31,6,58,32,7,56,33,17,56,34,16,54,35,17,54,36,16,62,37,6,62,38,6,60,39,7,60,40,6,60,41,6,60,42,4,32,43,2,59,43,4,93,43,1,32,44,2,58,44,4,93,44,2,32,45,2,
  58,45,4,93,45,2,32,46,2,58,46,3,93,46,2,32,47,5,58,47,2,89,47,6,32,48,5,58,48,2,89,48,5,31,53,65,31,54,65,88,22,2,88,23,2,88,24,2,87,25,2,87,26,2,93,26,3,45,27,33,92,27,4,44,28,35,92,28,3,43,29,37,
  90,29,3,42,30,3,78,30,2,42,31,3,78,31,2,42,32,3,78,32,2,42,33,3,78,33,5,92,33,5,42,34,3,78,34,5,92,34,5,42,35,3,78,35,5,42,36,3,78,36,5,42,37,3,78,37,5,42,38,3,78,38,5,42,39,3,78,39,5,42,40,3,
  78,40,5,42,41,3,78,41,2,42,42,3,78,42,2,43,43,37,43,44,36,44,45,34,24,58,80,24,59,80,86,22,2,86,23,2,86,24,1,85,25,1,85,26,1,90,26,3,47,27,32,89,27,3,46,28,34,88,28,2,45,29,2,78,29,2,45,30,2,78,30,2,
  45,31,2,50,31,4,57,31,4,63,31,5,70,31,5,78,31,4,45,32,2,49,32,5,57,32,5,63,32,5,70,32,6,78,32,5,89,32,5,45,33,2,49,33,5,57,33,5,63,33,5,70,33,6,78,33,5,45,34,2,49,34,5,57,34,5,63,34,5,70,34,6,
  78,34,5,45,35,2,49,35,6,57,35,4,63,35,5,70,35,6,78,35,5,45,36,2,49,36,6,57,36,4,63,36,5,70,36,6,78,36,5,45,37,2,49,37,6,57,37,4,63,37,5,70,37,6,78,37,5,45,38,2,78,38,2,45,39,2,78,39,2,45,40,35,
  46,41,33,47,42,31,29,53,70,29,54,70,49,59,1,53,59,1,28,22,6,93,22,6,28,23,2,97,23,2,28,24,1,98,24,1,28,25,1,98,25,1,28,26,1,98,26,1,28,27,1,43,27,2,52,27,3,72,27,3,82,27,2,98,27,1,43,28,3,52,28,3,
  72,28,3,81,28,3,43,29,5,50,29,4,73,29,4,79,29,5,45,30,3,50,30,2,75,30,2,79,30,3,45,31,7,75,31,7,47,32,4,76,32,4,47,33,4,77,33,3,45,34,7,75,34,7,45,35,3,50,35,2,75,35,3,79,35,3,43,36,5,50,36,4,
  73,36,5,79,36,5,43,37,3,52,37,3,72,37,3,81,37,3,43,38,3,52,38,3,72,38,3,82,38,2,56,44,15,55,45,16,55,46,16,28,47,1,56,47,15,98,47,1,28,48,1,98,48,1,28,49,1,98,49,1,28,50,2,98,50,1,28,51,6,93,51,6,
  28,52,5,93,52,6,26,58,75,26,59,75
};

const uint16_t FULL_OFFSETS[20] PROGMEM = { 0, 71, 156, 272, 361, 471, 515, 584, 703, 777, 829, 907, 995, 1086, 1182, 1276, 1344, 1417, 1483, 1580 };
const uint16_t FULL_LENGTHS[20] PROGMEM = { 71, 85, 116, 89, 110, 44, 69, 119, 74, 52, 78, 88, 91, 96, 94, 68, 73, 66, 97, 104 };
const uint8_t  FULL_SPANS[5052] PROGMEM = {
  20,5,12,96,5,12,20,6,12,96,6,12,20,7,12,96,7,12,20,8,12,96,8,12,20,9,12,96,9,12,20,10,12,96,10,12,20,11,12,96,11,12,20,12,12,96,12,12,20,13,12,96,13,12,20,14,12,96,14,12,20,15,12,96,15,12,20,16,12,96,16,12,
  20,17,12,96,17,12,20,18,12,96,18,12,20,19,12,96,19,12,20,20,12,96,20,12,20,21,12,96,21,12,20,22,12,96,22,12,20,23,12,96,23,12,20,24,12,96,24,12,20,25,12,96,25,12,20,26,12,96,26,12,20,27,12,96,27,12,20,28,12,96,28,12,
  20,29,12,96,29,12,20,30,12,96,30,12,20,31,12,96,31,12,20,32,12,96,32,12,20,33,12,96,33,12,20,34,12,96,34,12,20,35,12,96,35,12,20,36,12,96,36,12,54,52,21,54,53,21,54,54,21,54,55,21,54,56,21,54,57,21,54,58,21,18,8,7,
  102,8,7,18,9,7,102,9,7,18,10,7,102,10,7,18,11,7,102,11,7,15,12,14,98,12,15,15,13,15,97,13,16,15,14,15,97,14,16,15,15,15,97,15,16,10,16,23,94,16,9,107,16,9,10,17,8,25,17,8,94,17,8,108,17,8,10,18,10,25,18,8,
  94,18,8,108,18,8,10,19,10,25,19,10,92,19,10,108,19,12,10,20,8,26,20,10,92,20,7,112,20,8,6,21,10,29,21,9,88,21,10,112,21,10,6,22,9,30,22,9,88,22,9,113,22,9,6,23,9,30,23,9,88,23,9,113,23,9,6,24,8,30,24,9,
  88,24,9,113,24,9,6,25,6,33,25,6,88,25,6,116,25,6,6,26,6,33,26,6,88,26,6,116,26,6,6,27,6,33,27,6,88,27,6,116,27,6,6,28,6,33,28,6,88,28,6,116,28,6,48,43,5,73,43,6,48,44,5,73,44,6,48,45,5,73,45,6,
  48,46,5,72,46,7,48,47,5,72,47,7,48,48,31,48,49,30,48,50,30,48,51,29,52,52,23,52,53,23,52,54,23,52,55,23,17,7,4,108,7,4,17,8,4,108,8,4,17,9,4,108,9,4,17,10,4,108,10,4,17,11,4,108,11,4,20,12,2,38,12,9,
  82,12,9,106,12,3,20,13,3,38,13,9,82,13,9,106,13,3,20,14,3,38,14,9,82,14,9,106,14,3,20,15,3,38,15,9,82,15,9,106,15,3,11,16,2,20,16,3,38,16,9,82,16,9,106,16,2,115,16,3,10,17,3,20,17,3,38,17,9,82,17,10,
  106,17,2,115,17,4,10,18,4,38,18,9,82,18,10,113,18,6,10,19,6,38,19,9,82,19,10,112,19,4,12,20,5,38,20,9,82,20,10,112,20,4,12,21,6,38,21,9,82,21,10,111,21,4,15,22,3,38,22,9,82,22,10,111,22,2,38,23,9,82,23,10,
  6,24,5,38,24,9,82,24,10,119,24,3,6,25,8,38,25,9,82,25,10,113,25,9,6,26,8,38,26,9,82,26,10,113,26,9,6,27,8,38,27,9,82,27,10,114,27,8,38,28,9,82,28,10,38,29,9,82,29,10,38,30,9,82,30,10,38,31,9,82,31,10,
  38,32,9,82,32,10,38,33,8,82,33,9,53,38,24,53,39,24,53,40,24,53,41,24,53,42,4,72,42,5,53,43,3,73,43,4,53,44,3,73,44,4,53,45,3,73,45,4,53,46,3,73,46,4,53,47,4,73,47,4,56,48,4,69,48,5,56,49,5,69,49,5,
  56,50,5,69,50,5,56,51,5,69,51,4,60,52,10,60,53,10,60,54,10,60,55,9,14,5,1,16,5,9,103,5,9,14,6,12,103,6,10,14,7,12,103,7,10,14,8,12,103,8,10,14,9,12,103,9,10,14,10,12,102,10,11,14,11,12,98,11,14,14,12,12,
  98,12,9,14,13,12,98,13,9,14,14,12,97,14,10,14,15,12,95,15,8,14,16,12,93,16,10,14,17,12,93,17,10,14,18,12,89,18,14,14,19,12,88,19,15,14,20,12,88,20,10,14,21,12,88,21,10,14,22,12,88,22,10,14,23,12,88,23,12,14,24,12,
  89,24,12,14,25,12,93,25,10,14,26,12,93,26,10,14,27,12,94,27,13,14,28,12,98,28,10,14,29,12,98,29,10,14,30,12,98,30,10,14,31,12,98,31,14,14,32,12,98,32,14,14,33,12,103,33,9,14,34,12,103,34,9,14,35,12,103,35,9,14,36,12,
  103,36,10,14,37,12,103,37,5,109,37,3,47,44,6,70,44,6,47,45,6,70,45,6,47,46,6,70,46,6,47,47,6,69,47,7,47,48,6,69,48,7,47,49,6,69,49,7,47,50,29,47,51,29,49,52,24,49,53,24,52,54,18,52,55,18,52,56,18,52,57,18,
  53,58,17,36,11,4,89,11,5,35,12,5,89,12,5,35,13,6,88,13,7,33,14,10,86,14,11,33,15,11,85,15,12,33,16,11,85,16,12,32,17,4,39,17,8,82,17,7,94,17,6,29,18,7,40,18,7,82,18,7,94,18,6,9,19,3,29,19,7,40,19,7,
  82,19,7,94,19,6,117,19,3,8,20,4,29,20,4,41,20,9,79,20,7,97,20,7,117,20,3,8,21,6,26,21,7,44,21,6,79,21,6,97,21,7,115,21,5,9,22,5,26,22,7,45,22,5,79,22,6,98,22,6,115,22,5,11,23,3,26,23,4,45,23,5,
  79,23,4,99,23,5,115,23,3,11,24,5,26,24,4,46,24,4,79,24,4,99,24,5,114,24,3,13,25,3,26,25,4,46,25,4,79,25,4,99,25,5,114,25,2,26,26,4,47,26,3,6,27,4,118,27,4,6,28,6,117,28,5,6,29,5,117,29,5,114,30,3,
  12,31,4,114,31,3,12,32,4,114,32,3,11,33,5,114,33,3,9,34,6,116,34,4,8,35,4,54,35,22,117,35,3,8,36,4,53,36,23,117,36,3,53,37,23,53,38,23,53,39,23,53,40,4,72,40,4,53,41,4,72,41,4,53,42,4,72,42,4,53,43,4,
  72,43,4,53,44,4,72,44,4,53,45,7,69,45,7,57,46,3,69,46,4,57,47,3,69,47,4,57,48,4,68,48,5,57,49,16,60,50,10,60,51,10,60,52,10,93,5,9,111,5,4,92,6,11,110,6,4,92,7,10,109,7,4,93,8,9,109,8,4,97,9,4,
  108,9,3,97,10,4,107,10,4,96,11,4,106,11,9,94,12,5,106,12,9,94,13,4,106,13,9,92,14,10,92,15,11,92,16,11,92,17,11,13,35,25,68,35,25,13,36,26,68,36,25,13,37,26,68,37,25,13,38,26,68,38,25,13,39,26,68,39,25,13,40,26,
  68,40,25,12,41,27,68,41,25,13,42,25,68,42,25,46,53,14,46,54,14,46,55,14,46,56,14,47,57,13,47,58,13,97,5,8,113,5,5,83,6,11,98,6,7,113,6,4,83,7,11,101,7,4,112,7,4,84,8,10,101,8,3,110,8,5,88,9,5,99,9,4,
  110,9,4,88,10,4,99,10,4,109,10,5,86,11,5,97,11,4,109,11,9,86,12,4,97,12,8,109,12,9,85,13,4,97,13,9,109,13,9,84,14,4,97,14,8,83,15,11,83,16,11,83,17,11,10,31,5,34,31,5,67,31,4,90,31,5,10,32,5,34,32,4,
  67,32,5,90,32,5,10,33,5,34,33,4,67,33,5,90,33,5,10,34,5,34,34,4,67,34,5,90,34,5,10,35,5,33,35,5,67,35,5,90,35,5,10,36,28,67,36,28,10,37,28,67,37,28,10,38,28,67,38,27,15,39,19,70,39,21,15,40,19,70,40,21,
  15,41,19,70,41,20,46,53,13,45,54,14,45,55,14,45,56,14,45,57,14,46,58,13,17,7,4,108,7,4,17,8,4,108,8,4,17,9,4,108,9,4,17,10,4,108,10,4,17,11,4,108,11,4,18,12,5,106,12,3,19,13,4,39,13,8,82,13,10,106,13,3,
  19,14,4,39,14,8,82,14,10,106,14,3,20,15,3,39,15,8,82,15,10,106,15,2,21,16,2,39,16,8,82,16,10,106,16,2,115,16,4,21,17,2,39,17,8,82,17,10,106,17,2,114,17,5,39,18,8,82,18,10,113,18,3,39,19,8,82,19,10,112,19,3,
  39,20,8,82,20,10,111,20,4,39,21,8,82,21,10,110,21,5,39,22,8,82,22,10,110,22,3,39,23,8,82,23,10,6,24,8,39,24,8,82,24,10,118,24,4,6,25,8,39,25,8,82,25,10,118,25,4,6,26,8,39,26,8,82,26,10,115,26,7,7,27,10,
  39,27,8,82,27,10,112,27,7,10,28,7,39,28,8,82,28,10,112,28,6,13,29,4,39,29,8,82,29,10,112,29,4,14,30,3,39,30,8,82,30,10,112,30,3,14,31,2,39,31,8,82,31,10,113,31,1,39,32,8,82,32,10,39,33,8,83,33,8,59,36,10,
  60,37,10,59,38,11,59,39,11,56,40,4,70,40,3,56,41,4,70,41,3,56,42,4,70,42,3,56,43,4,70,43,3,56,44,4,70,44,3,56,45,4,70,45,3,56,46,4,70,46,3,56,47,4,70,47,3,56,48,4,70,48,3,56,49,4,70,49,3,56,50,4,
  70,50,3,56,51,4,70,51,3,57,52,17,60,53,10,60,54,10,60,55,10,94,5,15,94,6,4,104,6,5,94,7,4,105,7,4,94,8,4,105,8,4,105,9,4,102,10,7,100,11,7,100,12,6,100,13,6,100,14,6,100,15,4,100,16,3,100,17,3,18,19,9,
  70,19,10,18,20,9,70,20,10,100,20,3,18,21,9,70,21,10,100,21,4,18,22,9,70,22,10,100,22,4,18,23,9,70,23,10,100,23,4,18,24,9,70,24,10,18,25,9,70,25,10,18,26,9,70,26,10,18,27,9,70,27,10,18,28,9,70,28,10,18,29,9,
  70,29,10,18,30,9,70,30,10,18,31,9,70,31,10,18,32,9,70,32,10,18,33,9,70,33,10,18,34,9,70,34,10,18,35,9,70,35,10,18,36,9,70,36,10,18,37,9,70,37,10,18,38,9,70,38,10,18,39,9,70,39,10,18,40,9,70,40,10,18,41,9,
  70,41,10,18,42,9,71,42,8,42,53,12,42,54,13,42,55,13,42,56,13,42,57,13,42,58,13,95,5,5,104,5,5,114,5,4,96,6,4,104,6,5,114,6,4,95,7,5,104,7,5,114,7,4,96,8,4,105,8,4,114,8,4,10,26,28,70,26,26,10,27,28,
  70,27,26,10,28,28,70,28,26,10,29,28,70,29,26,10,30,28,70,30,26,10,31,28,70,31,26,10,32,28,70,32,26,29,33,9,70,33,4,91,33,5,29,34,9,70,34,4,91,34,5,29,35,9,70,35,4,91,35,5,29,36,9,70,36,4,91,36,5,29,37,8,
  70,37,4,60,47,5,59,48,7,59,49,7,59,50,7,58,51,8,58,52,8,46,53,20,46,54,20,46,55,16,46,56,16,46,57,16,46,58,16,30,7,6,94,7,5,29,8,7,93,8,7,29,9,7,92,9,9,29,10,7,92,10,9,29,11,7,92,11,9,29,12,7,
  92,12,9,29,13,7,92,13,9,29,14,7,92,14,9,29,15,7,92,15,9,27,16,9,92,16,9,102,16,1,26,17,10,92,17,11,25,18,11,92,18,13,25,19,11,92,19,13,25,20,11,92,20,13,25,21,11,92,21,13,25,22,11,92,22,13,6,23,30,96,23,26,
  6,24,29,97,24,25,6,25,26,98,25,24,6,26,26,98,26,24,6,27,26,98,27,24,6,28,25,98,28,24,6,29,20,103,29,19,6,30,20,103,30,19,6,31,20,103,31,19,6,32,20,103,32,19,53,40,22,53,41,22,53,42,22,53,43,22,53,44,22,48,45,32,
  48,46,32,48,47,12,68,47,12,48,48,9,72,48,8,48,49,7,72,49,8,48,50,7,73,50,7,48,51,7,73,51,7,48,52,7,73,52,7,48,53,7,73,53,7,48,54,6,73,54,7,48,55,5,73,55,7,7,10,36,84,10,38,7,11,36,84,11,38,7,12,36,
  84,12,38,6,13,37,84,13,38,6,14,37,84,14,38,6,15,37,84,15,38,6,16,37,84,16,38,7,17,35,84,17,38,7,18,34,85,18,36,16,19,11,102,19,10,16,20,11,102,20,10,17,21,10,102,21,9,18,22,9,102,22,8,21,23,6,102,23,5,22,24,5,
  102,24,4,22,25,5,102,25,8,21,26,6,102,26,9,16,27,11,102,27,10,16,28,11,102,28,10,16,29,11,102,29,10,16,30,11,102,30,10,16,31,11,102,31,10,16,32,11,102,32,10,16,33,11,102,33,10,16,34,11,102,34,10,16,35,11,102,35,10,16,36,11,
  102,36,10,16,37,11,106,37,5,17,38,10,107,38,3,18,39,9,18,40,9,102,40,8,21,41,6,102,41,8,22,42,5,102,42,8,21,43,6,102,43,9,18,44,9,102,44,10,16,45,10,102,45,10,16,46,6,23,46,3,102,46,10,16,47,9,102,47,10,16,48,8,
  102,48,10,16,49,8,102,49,10,16,50,8,102,50,10,16,51,8,102,51,10,17,52,6,103,52,8,18,53,5,104,53,6,105,5,3,111,5,3,103,6,5,111,6,3,103,7,5,111,7,6,100,8,6,112,8,6,100,9,6,113,9,5,101,10,1,114,10,3,100,13,6,
  112,13,6,100,14,6,112,14,6,102,15,6,110,15,8,104,16,4,110,16,4,105,17,3,110,17,4,105,18,3,110,18,4,12,19,5,82,19,4,105,19,3,110,19,4,10,20,7,82,20,7,105,20,3,111,20,2,10,21,7,82,21,7,10,22,9,79,22,10,10,23,10,
  79,23,10,10,24,12,76,24,13,13,25,9,76,25,10,13,26,9,76,26,10,13,27,13,72,27,11,17,28,9,72,28,10,17,29,9,72,29,10,17,30,15,68,30,14,17,31,15,68,31,14,17,32,15,68,32,14,17,33,15,68,33,14,17,34,15,68,34,14,17,35,10,
  72,35,11,17,36,9,72,36,11,17,37,9,72,37,11,17,38,9,72,38,10,17,39,9,72,39,11,17,40,9,72,40,10,17,41,9,72,41,11,18,42,8,75,42,7,43,50,13,43,51,13,43,52,13,43,53,13,43,54,13,39,55,4,44,55,2,52,55,2,55,55,5,
  39,56,4,56,56,4,39,57,4,56,57,4,39,58,4,56,58,4,35,14,9,84,14,9,35,15,9,84,15,9,35,16,9,84,16,9,35,17,9,84,17,9,35,18,9,84,18,9,35,19,9,84,19,9,35,20,9,84,20,9,35,21,9,84,21,9,35,22,9,84,22,9,
  35,23,9,84,23,9,35,24,9,84,24,9,35,25,9,84,25,9,35,26,9,84,26,9,35,27,9,84,27,9,35,28,9,84,28,9,35,29,9,84,29,9,35,30,9,84,30,9,35,31,9,84,31,9,35,32,9,84,32,9,35,33,9,84,33,9,35,34,9,84,34,9,
  35,35,9,84,35,9,35,36,9,84,36,9,36,37,8,84,37,9,12,38,5,24,38,4,107,38,4,118,38,4,12,39,5,24,39,4,107,39,4,118,39,4,12,40,5,24,40,4,107,40,4,118,40,4,11,41,6,22,41,6,105,41,6,116,41,6,10,42,7,21,42,7,
  104,42,7,116,42,6,9,43,6,20,43,7,103,43,6,114,43,6,9,44,5,20,44,6,103,44,6,114,44,6,6,45,7,18,45,6,100,45,7,112,45,6,6,46,6,17,46,7,100,46,6,111,46,7,6,47,5,17,47,6,100,47,5,111,47,5,6,48,5,17,48,5,
  100,48,5,111,48,5,6,49,5,17,49,5,100,49,5,111,49,5,109,5,3,116,5,4,108,6,4,116,6,4,108,7,6,115,7,5,108,8,12,108,9,12,108,10,12,111,11,7,111,12,7,113,13,3,113,14,3,113,15,2,28,16,3,75,16,7,89,16,6,11,17,8,
  24,17,8,75,17,8,88,17,8,11,18,8,24,18,8,75,18,8,88,18,8,11,19,8,24,19,8,75,19,8,88,19,8,11,20,9,23,20,10,71,20,14,86,20,13,7,21,14,22,21,14,71,21,29,7,22,14,22,22,14,71,22,29,7,23,29,71,23,29,7,24,29,
  71,24,29,7,25,29,71,25,29,7,26,29,71,26,29,7,27,29,71,27,29,7,28,29,71,28,29,11,29,21,75,29,21,11,30,21,75,30,21,11,31,21,75,31,21,11,32,21,75,32,21,15,33,13,79,33,13,16,34,12,79,34,13,16,35,12,79,35,13,16,36,12,
  79,36,13,19,37,5,83,37,5,19,38,5,83,38,5,19,39,5,83,39,5,19,40,5,83,40,5,41,46,4,63,46,4,40,47,5,62,47,5,40,48,5,62,48,5,40,49,5,62,49,5,40,50,6,62,50,5,40,51,6,62,51,5,40,52,27,40,53,27,41,54,23,
  45,55,18,45,56,18,45,57,18,46,58,8,19,8,90,18,9,91,18,10,91,18,11,91,18,12,91,19,13,90,25,14,33,71,14,32,25,15,33,71,15,32,25,16,33,71,16,32,25,17,33,71,17,32,25,18,33,71,18,32,28,19,26,74,19,26,28,20,26,74,20,26,
  28,21,26,75,21,25,32,22,19,78,22,19,32,23,19,78,23,19,32,24,19,78,24,19,32,25,19,81,25,1,83,25,13,112,26,1,111,27,3,111,28,3,111,29,3,110,30,5,71,31,4,109,31,6,70,32,5,108,32,4,113,32,5,71,33,4,107,33,4,114,33,5,
  54,34,4,68,34,7,105,34,6,114,34,6,54,35,4,68,35,7,105,35,6,114,35,5,55,36,19,108,36,9,55,37,17,109,37,7,57,38,14,110,38,6,58,39,13,111,39,3,58,40,13,111,40,3,111,41,3,119,51,3,6,52,116,6,53,116,6,54,14,41,54,8,
  19,5,8,68,5,3,100,5,8,19,6,4,68,6,3,105,6,3,19,7,3,68,7,3,105,7,3,19,8,3,65,8,6,105,8,3,19,9,3,64,9,4,69,9,2,105,9,3,19,10,3,64,10,7,105,10,3,20,11,2,62,11,9,105,11,3,62,12,6,69,12,2,
  62,13,6,59,14,9,59,15,9,59,16,9,57,17,10,57,18,8,57,19,8,54,20,23,54,21,23,54,22,23,51,23,25,51,24,23,51,25,23,52,26,21,62,27,9,62,28,9,60,29,10,59,30,9,59,31,9,59,32,9,59,33,6,59,34,6,20,35,2,57,35,7,
  106,35,2,19,36,3,57,36,5,105,36,3,19,37,3,57,37,5,105,37,3,19,38,3,57,38,5,105,38,3,19,39,3,57,39,5,105,39,3,19,40,3,57,40,3,105,40,3,19,41,8,56,41,4,100,41,8,19,42,8,56,42,4,100,42,8,18,49,92,18,50,92,
  18,51,92,98,5,2,98,6,2,98,7,2,98,8,2,96,9,2,95,10,3,95,11,3,105,11,3,96,12,2,104,12,4,36,13,47,103,13,5,35,14,49,102,14,5,34,15,51,101,15,4,33,16,5,43,16,1,83,16,3,101,16,2,33,17,4,83,17,3,33,18,4,
  83,18,3,33,19,4,83,19,3,33,20,4,83,20,7,33,21,4,83,21,8,103,21,8,33,22,4,83,22,8,103,22,8,33,23,4,83,23,7,103,23,7,33,24,4,83,24,7,33,25,4,83,25,8,33,26,4,83,26,8,33,27,4,83,27,8,33,28,4,83,28,8,
  33,29,4,83,29,8,33,30,4,83,30,7,33,31,4,83,31,7,33,32,4,83,32,3,33,33,4,83,33,3,33,34,4,83,34,3,33,35,53,34,36,52,35,37,50,36,38,48,7,56,113,7,57,113,7,58,113,96,5,2,96,6,2,96,7,2,95,8,2,94,9,2,
  94,10,2,102,10,3,41,11,42,101,11,4,40,12,45,100,12,3,39,13,47,99,13,4,38,14,49,98,14,3,37,15,3,84,15,3,37,16,3,84,16,3,37,17,3,84,17,3,37,18,3,43,18,7,53,18,8,63,18,7,73,18,7,84,18,6,37,19,3,43,19,7,
  53,19,7,63,19,7,73,19,8,84,19,7,100,19,7,37,20,3,43,20,7,53,20,8,63,20,7,73,20,8,84,20,7,100,20,7,37,21,3,43,21,7,53,21,8,63,21,7,73,21,8,84,21,7,37,22,3,43,22,7,53,22,7,63,22,7,73,22,8,84,22,7,
  37,23,3,43,23,8,53,23,8,63,23,7,73,23,8,84,23,7,37,24,3,43,24,8,53,24,7,63,24,7,73,24,8,84,24,7,37,25,3,43,25,8,53,25,7,63,25,7,73,25,8,84,25,7,37,26,3,43,26,8,53,26,7,63,26,7,73,26,8,84,26,7,
  37,27,3,43,27,7,53,27,7,63,27,7,73,27,8,84,27,6,37,28,3,84,28,3,37,29,3,84,29,3,37,30,3,84,30,3,37,31,50,38,32,48,39,33,46,14,49,100,14,50,100,14,51,100,42,58,3,48,58,2,12,5,9,106,5,9,12,6,9,106,6,9,
  12,7,3,112,7,3,12,8,3,112,8,3,12,9,3,112,9,3,12,10,3,112,10,3,12,11,3,112,11,3,12,12,3,34,12,4,47,12,4,76,12,4,89,12,4,112,12,3,34,13,4,47,13,4,76,13,4,89,13,4,34,14,4,47,14,4,76,14,4,89,14,4,
  34,15,7,44,15,7,76,15,7,86,15,7,37,16,4,44,16,3,80,16,3,86,16,4,37,17,4,44,17,3,80,17,3,86,17,4,37,18,10,80,18,10,40,19,5,82,19,5,40,20,5,82,20,5,40,21,5,83,21,4,37,22,10,80,22,10,37,23,4,44,23,3,
  80,23,4,86,23,4,37,24,4,44,24,3,80,24,4,86,24,4,36,25,5,44,25,4,79,25,4,86,25,5,34,26,6,45,26,6,76,26,6,87,26,6,34,27,4,47,27,4,76,27,4,89,27,4,34,28,4,47,28,4,76,28,4,89,28,4,34,29,3,48,29,2,
  77,29,2,90,29,3,52,37,22,52,38,22,52,39,22,12,40,3,52,40,22,112,40,3,12,41,3,53,41,21,112,41,3,12,42,3,112,42,3,12,43,3,112,43,3,12,44,3,112,44,3,12,45,3,112,45,3,12,46,9,106,46,9,12,47,9,106,47,9,13,48,7,
  106,48,8,10,56,107,10,57,107,10,58,107
};

static void setCtsState(BleCtsState st, unsigned long delayMs = 0) {
  portENTER_CRITICAL(&bleMux);
  bleCtsState = st;
  if (delayMs > 0) bleNextCtsProbeMs = millis() + delayMs;
  portEXIT_CRITICAL(&bleMux);
}

uint8_t activeContrast() { return BRIGHTNESS_VALS[constrain((int)brightnessLevel, 1, 5) - 1]; }
void setBrightnessLevel(uint8_t lvl, bool persist = true) {
  brightnessLevel = (uint8_t)constrain((int)lvl, 1, 5);
  if (currentMode != MODE_SLEEP) u8g2.setContrast(activeContrast());
  if (persist) prefs.putUChar("bri_lvl", brightnessLevel);
}

uint32_t getStopwatchMs() { return swAccumMs + (swRunning ? (uint32_t)(millis() - swStartMs) : 0); }
void toggleStopwatch() {
  unsigned long now = millis();
  if (swRunning) { swAccumMs += (uint32_t)(now - swStartMs); swRunning = false; }
  else { swStartMs = now; swRunning = true; }
}
void resetStopwatch() { swRunning = false; swAccumMs = 0; swStartMs = 0; }

void drawFaceFromTable(int idx, bool fullScreen) {
  idx = constrain(idx, 0, 19);
  const uint16_t* offs = fullScreen ? FULL_OFFSETS : HOME_OFFSETS;
  const uint16_t* lens = fullScreen ? FULL_LENGTHS : HOME_LENGTHS;
  const uint8_t* spans = fullScreen ? FULL_SPANS : HOME_SPANS;
  uint16_t off = pgm_read_word(&offs[idx]), len = pgm_read_word(&lens[idx]);
  u8g2.setDrawColor(1);
  for (uint16_t i = 0; i < len; i++) {
    uint32_t b = (uint32_t)(off + i) * 3;
    u8g2.drawHLine(pgm_read_byte(&spans[b]), pgm_read_byte(&spans[b + 1]), pgm_read_byte(&spans[b + 2]));
  }
}

void drawDinoStep(int x, int y, bool step) {
  u8g2.setDrawColor(1); u8g2.drawBox(x + 5, y, 6, 4);
  u8g2.setDrawColor(0); u8g2.drawPixel(x + 9, y + 1);
  u8g2.setDrawColor(1);
  u8g2.drawBox(x + 2, y + 3, 6, 6);
  u8g2.drawBox(x, y + 4, 2, 2);
  u8g2.drawPixel(x + 8, y + 5);
  u8g2.drawBox(x + 3, y + 9, 2, step ? 1 : 2);
  u8g2.drawBox(x + 6, y + 9, 2, step ? 2 : 1);
}

void playBootSplash() {
  for (int f = 0; f < 16; f++) {
    u8g2.clearBuffer();
    u8g2.setDrawColor(1);
    u8g2.drawHLine(0, GROUND_Y, 128);
    drawDinoStep(6 + f, GROUND_Y - DINO_H, (f < 14) && ((f % 2) == 1));
    u8g2.setFont(u8g2_font_logisoso16_tr);
    u8g2.drawStr((128 - u8g2.getStrWidth(BOOT_TITLE)) / 2, 24, BOOT_TITLE);
    u8g2.setFont(u8g2_font_5x7_tf);
    u8g2.drawStr((128 - u8g2.getStrWidth(BOOT_OWNER)) / 2, 36, BOOT_OWNER);
    u8g2.drawStr(78, 53, BOOT_VERSION);
    u8g2.sendBuffer();
    delay(95);
  }
  delay(250);
}

float dinoSpeed() { return min(160.0f, 60.0f + dinoScore * 0.15f); }
void placeCactus(int i, float afterX) {
  cacti[i].x = afterX + dinoSpeed() * 0.6f + random(25, 75);
  cacti[i].w = random(4, 8); cacti[i].h = random(8, 15);
}
void dinoStart() {
  dinoPlaying = true; dinoScore = 0; dinoDist = dinoY = dinoVy = groundShift = 0;
  placeCactus(0, 110); placeCactus(1, cacti[0].x); dinoLastFrame = millis();
}
void dinoJump() { if (dinoY <= 0.0f) dinoVy = 230.0f; }
void dinoUpdate() {
  if (!dinoPlaying) return;
  uint32_t t = millis(); float dt = min(0.05f, (t - dinoLastFrame) / 1000.0f); dinoLastFrame = t;
  if (dinoY > 0.0f || dinoVy > 0.0f) { dinoVy -= 900.0f * dt; dinoY += dinoVy * dt; if (dinoY <= 0.0f) dinoY = dinoVy = 0.0f; }
  float sp = dinoSpeed(); dinoDist += sp * dt; dinoScore = (uint32_t)(dinoDist / 5.0f); groundShift += sp * dt;
  for (int i = 0; i < 2; i++) {
    cacti[i].x -= sp * dt;
    if (cacti[i].x + cacti[i].w < 0) placeCactus(i, max(cacti[0].x, cacti[1].x));
    int dTop = GROUND_Y - DINO_H - (int)dinoY + 2, dBot = GROUND_Y - (int)dinoY, cTop = GROUND_Y - cacti[i].h;
    if (DINO_X + 2 < cacti[i].x + cacti[i].w && DINO_X + DINO_W - 2 > cacti[i].x && dBot > cTop && dTop < GROUND_Y) {
      dinoPlaying = false; dinoOverAt = t;
      if (dinoScore > dinoBest) { dinoBest = dinoScore; prefs.putULong("dino_hi", dinoBest); }
    }
  }
}

void initInputPin() {
#if INPUT_AUTO_DETECT
  pinMode(PIN_INPUT, INPUT_PULLUP); delay(5); int vUp = digitalRead(PIN_INPUT);
  pinMode(PIN_INPUT, INPUT_PULLDOWN); delay(5); int vDn = digitalRead(PIN_INPUT);
  touchActiveHigh = (vUp == LOW && vDn == LOW);
  Serial.println(touchActiveHigh ? F("[INPUT] Auto-detected TTP223 (Active HIGH)") : F("[INPUT] Auto-detected push button (Active LOW)"));
#else
  touchActiveHigh = USE_TOUCH_SENSOR;
#endif
  pinMode(PIN_INPUT, touchActiveHigh ? INPUT : INPUT_PULLUP);
}

InputEvent readInput() {
  static int lastReading = -1, clicks = 0;
  static bool debouncedActive = false, longPressFired = false, pendingPress = false;
  static unsigned long lastDebounceMs = 0, pressStartMs = 0, lastReleaseMs = 0;
  unsigned long now = millis();
  int r = digitalRead(PIN_INPUT);
  if (lastReading == -1) lastReading = r;
  if (r != lastReading) lastDebounceMs = now;
  lastReading = r;
  bool activeNow = touchActiveHigh ? (r == HIGH) : (r == LOW);
  if (now - lastDebounceMs >= 20 && activeNow != debouncedActive) {
    debouncedActive = activeNow;
    if (debouncedActive) { pressStartMs = now; longPressFired = false; pendingPress = true; }
    else if (!longPressFired) { clicks++; lastReleaseMs = now; }
  }
  if (pendingPress) { pendingPress = false; return EVT_PRESS_DOWN; }
  if (debouncedActive && !longPressFired && (now - pressStartMs >= 700)) { longPressFired = true; clicks = 0; return EVT_LONG_PRESS; }
  if (clicks > 0 && !debouncedActive) {
    if (clicks >= 2) { clicks = 0; return EVT_DOUBLE_CLICK; }
    if (now - lastReleaseMs >= 300) { clicks = 0; return EVT_SINGLE_CLICK; }
  }
  return EVT_NONE;
}

void formatDateStr(char* buf, size_t len) {
  static const char* days[] = {"SUN","MON","TUE","WED","THU","FRI","SAT"};
  static const char* mons[] = {"JAN","FEB","MAR","APR","MAY","JUN","JUL","AUG","SEP","OCT","NOV","DEC"};
  snprintf(buf, len, "%s %02d %s", days[constrain(cachedNow.dayOfTheWeek(), 0, 6)],
           cachedNow.day(), mons[constrain(cachedNow.month() - 1, 0, 11)]);
}

void formatTimeStr(char* buf, size_t len, bool withSec) {
  int h = cachedNow.hour(), m = cachedNow.minute(), s = cachedNow.second();
  if (withSec) {
    if (DEFAULT_12H_FORMAT) { h %= 12; if (h == 0) h = 12; }
    snprintf(buf, len, "%02d:%02d:%02d", h, m, s);
  } else if (DEFAULT_12H_FORMAT) {
    int dh = h % 12; if (dh == 0) dh = 12;
    snprintf(buf, len, "%02d:%02d %s", dh, m, (h >= 12) ? "PM" : "AM");
  } else {
    snprintf(buf, len, "%02d:%02d", h, m);
  }
}

void setLocalEpoch(uint32_t localSec, const char* src, bool persist = true, bool live = true) {
  softEpochSaved = localSec; lastSoftTickMs = millis(); cachedNow = DateTime(localSec); timeSource = src;
  if (live) timeSyncedLive = true;
  if (rtcAvailable && live) rtc.adjust(cachedNow);
  if (persist) {
    prefs.putULong("epoch", localSec); prefs.putLong("tzmin", tzOffsetMin); prefs.putString("sync_src", timeSource);
    lastNvsSaveMs = millis();
  }
}

void applyUtcAndTz(uint32_t utcSec, int32_t tzMin, const char* src) {
  tzOffsetMin = tzMin;
  int64_t l64 = (int64_t)utcSec + (int64_t)tzOffsetMin * 60LL;
  if (l64 > 1700000000LL) setLocalEpoch((uint32_t)l64, src, true, true);
}

void loadPrefsAndClock() {
  prefs.begin("dinokey", false);
  tzOffsetMin = prefs.getLong("tzmin", DEFAULT_TZ_MIN);
  wifiSsid1 = prefs.getString("ssid1", ""); wifiPass1 = prefs.getString("pass1", "");
  wifiSsid2 = prefs.getString("ssid2", ""); wifiPass2 = prefs.getString("pass2", "");
  dinoBest = max(dinoBest, (uint32_t)prefs.getULong("dino_hi", 0));
  brightnessLevel = (uint8_t)constrain((int)prefs.getUChar("bri_lvl", 5), 1, 5);

  uint32_t nvsEp = prefs.getULong("epoch", 0), compEp = DateTime(F(__DATE__), F(__TIME__)).unixtime() + 5;
  uint32_t seed = max(compEp, nvsEp);
  if (softBuildTag == compEp && softEpochSaved > seed) seed = softEpochSaved;
  softBuildTag = compEp; softEpochSaved = seed; lastSoftTickMs = lastNvsSaveMs = millis();
  cachedNow = DateTime(seed); timeSource = (nvsEp >= compEp) ? "NVS" : "EST";
}

void saveWifiCredentials(int slot, const String& ssid, const String& pass) {
  if (ssid.length() == 0) return;
  if (slot == 2) {
    wifiSsid2 = ssid; wifiPass2 = pass; prefs.putString("ssid2", ssid); prefs.putString("pass2", pass); wifiActiveSlot = 1;
  } else {
    if (wifiSsid1.length() > 0 && wifiSsid1 != ssid) {
      wifiSsid2 = wifiSsid1; wifiPass2 = wifiPass1; prefs.putString("ssid2", wifiSsid2); prefs.putString("pass2", wifiPass2);
    }
    wifiSsid1 = ssid; wifiPass1 = pass; prefs.putString("ssid1", ssid); prefs.putString("pass1", pass); wifiActiveSlot = 0;
  }
  wifiState = STA_IDLE; wifiStateMs = 0;
}

void clearWifiCredentials() {
  wifiSsid1 = wifiPass1 = wifiSsid2 = wifiPass2 = activeStaSsid = "";
  prefs.putString("ssid1", ""); prefs.putString("pass1", "");
  prefs.putString("ssid2", ""); prefs.putString("pass2", "");
  WiFi.disconnect(false); wifiState = STA_COOLDOWN; wifiStateMs = millis();
}

bool getSlotCreds(int slot, String& s, String& p) {
  if (slot == 0 && wifiSsid1.length() > 0) { s = wifiSsid1; p = wifiPass1; return true; }
  if (slot == 1 && wifiSsid2.length() > 0) { s = wifiSsid2; p = wifiPass2; return true; }
  if (slot == 2 && strcmp(WIFI_SSID, "YourWiFiName") != 0 && strlen(WIFI_SSID) > 0) { s = WIFI_SSID; p = WIFI_PASS; return true; }
  return false;
}
bool hasAnyWifiConfigured() { String s, p; return getSlotCreds(0, s, p) || getSlotCreds(1, s, p) || getSlotCreds(2, s, p); }

bool getBatInfo(bool& hasBat, float& pct, bool& fromBle, bool& chg) {
  fromBle = !batteryAvailable && (bleHostBatValid || bleClientConnected);
  hasBat = batteryAvailable || fromBle;
  pct = batteryAvailable ? batPercent : (bleHostBatValid ? bleHostBatPct : (float)lastBleBatSent);
  chg = batteryAvailable ? (batChargeRate > 0.05f) : bleHostBatCharging;
  return hasBat;
}

String buildStatusJson() {
  char ds[20], ts[16]; formatDateStr(ds, sizeof(ds)); formatTimeStr(ts, sizeof(ts), false);
  String wf = (WiFi.status() == WL_CONNECTED) ? activeStaSsid : (hasAnyWifiConfigured() ? (wifiState == STA_CONNECTING ? "Connecting..." : "Offline") : "AP Only");
  String ip = (WiFi.status() == WL_CONNECTED) ? WiFi.localIP().toString() : "";
  bool hasBat, fromBle, chg; float pct; getBatInfo(hasBat, pct, fromBle, chg);
  int effBat = hasBat ? (int)pct : -1;
  const char* batSrc = batteryAvailable ? "MAX17048" : (fromBle ? "BLE" : "NONE");
  return String("{\"time\":\"") + ts + "\",\"date\":\"" + ds + "\",\"sync\":\"" + timeSource +
         "\",\"live\":" + (timeSyncedLive ? "true" : "false") + ",\"bat\":" + effBat +
         ",\"batSrc\":\"" + batSrc + "\",\"batChg\":" + (chg ? "true" : "false") +
         ",\"wifi\":\"" + wf + "\",\"staIp\":\"" + ip + "\",\"ap\":\"" + AP_SSID +
         "\",\"apIp\":\"" + WiFi.softAPIP().toString() + "\",\"apClients\":" + WiFi.softAPgetStationNum() +
         ",\"ssid1\":\"" + wifiSsid1 + "\",\"ssid2\":\"" + wifiSsid2 + "\",\"bri\":" + (int)brightnessLevel +
         ",\"bleConn\":" + (bleClientConnected ? "true" : "false") + "}";
}

void updateBleStatusValue(bool notifyClients = false) {
  if (bleCmdChar) {
    bleCmdChar->setValue(buildStatusJson().c_str());
    if (notifyClients && bleClientConnected) bleCmdChar->notify();
  }
  if (bleBatChar) {
    uint8_t lvl = batteryAvailable ? (uint8_t)constrain((int)batPercent, 0, 100) : 100;
    bleBatChar->setValue(&lvl, 1); lastBleBatSent = lvl;
    if (notifyClients && bleClientConnected) bleBatChar->notify();
  }
}

void executeSyncCommand(const String& rawIn, const char* viaSrc) {
  String cmd = rawIn; cmd.trim();
  if (cmd.length() == 0) return;
  lastActivityMs = millis();
  if (currentMode == MODE_SLEEP) { currentMode = previousMode; u8g2.setContrast(activeContrast()); }

  if (cmd.startsWith("T:")) {
    int p1 = cmd.indexOf(':', 2), p2 = (p1 > 0) ? cmd.indexOf(':', p1 + 1) : -1, p3 = (p2 > 0) ? cmd.indexOf(':', p2 + 1) : -1;
    uint32_t utc = (uint32_t)strtoul((p1 > 0 ? cmd.substring(2, p1) : cmd.substring(2)).c_str(), nullptr, 10);
    int32_t tzm = (p1 > 0) ? (int32_t)atol((p2 > 0 ? cmd.substring(p1 + 1, p2) : cmd.substring(p1 + 1)).c_str()) : tzOffsetMin;
    if (utc > 1700000000UL) { bleGotDirectCmd = true; applyUtcAndTz(utc, tzm, viaSrc); }
    if (p2 > 0) {
      int bPct = atoi((p3 > 0 ? cmd.substring(p2 + 1, p3) : cmd.substring(p2 + 1)).c_str());
      bool chg = (p3 > 0) && (atoi(cmd.substring(p3 + 1).c_str()) != 0);
      if (bPct >= 0 && bPct <= 100) { bleHostBatPct = (float)bPct; bleHostBatCharging = chg; bleHostBatValid = true; }
    }
  } else if (cmd.startsWith("BAT:")) {
    int sep = cmd.indexOf(':', 4), bPct = atoi((sep > 0 ? cmd.substring(4, sep) : cmd.substring(4)).c_str());
    bool chg = (sep > 0) && (atoi(cmd.substring(sep + 1).c_str()) != 0);
    if (bPct >= 0 && bPct <= 100) { bleHostBatPct = (float)bPct; bleHostBatCharging = chg; bleHostBatValid = true; }
  } else if (cmd.startsWith("EPOCH ")) {
    unsigned long utc = 0; long tzm = tzOffsetMin;
    if (sscanf(cmd.c_str() + 6, "%lu %ld", &utc, &tzm) >= 1 && utc > 1700000000UL) { bleGotDirectCmd = true; applyUtcAndTz((uint32_t)utc, (int32_t)tzm, viaSrc); }
  } else if (cmd.startsWith("SET ")) {
    int y, mo, d, hh, mm, ss;
    if (sscanf(cmd.c_str() + 4, "%d-%d-%d %d:%d:%d", &y, &mo, &d, &hh, &mm, &ss) == 6) { bleGotDirectCmd = true; setLocalEpoch(DateTime(y, mo, d, hh, mm, ss).unixtime(), viaSrc, true, true); }
  } else if (cmd.startsWith("W:") || cmd.startsWith("WIFI ")) {
    String pay = cmd.startsWith("W:") ? cmd.substring(2) : cmd.substring(5);
    int sep = pay.indexOf('|');
    if (sep > 0) { String s = pay.substring(0, sep); s.trim(); saveWifiCredentials(1, s, pay.substring(sep + 1)); }
  } else if (cmd.startsWith("M:")) { int m = atoi(cmd.c_str() + 2); if (m >= 0 && m < 8) currentMode = (ScreenMode)m; }
  else if (cmd.startsWith("F:")) { int f = atoi(cmd.c_str() + 2); if (f >= 0 && f < 20) faceIdx = f; }
  else if (cmd.startsWith("B:")) { setBrightnessLevel((uint8_t)atoi(cmd.c_str() + 2), true); }
  else if (cmd == "SW:TOGGLE") toggleStopwatch();
  else if (cmd == "SW:RESET") resetStopwatch();
  else if (cmd == "CLR") clearWifiCredentials();
  else if (cmd == "STATUS") Serial.println(buildStatusJson());
  updateBleStatusValue(true);
}

int onBleBatReadCb(uint16_t, const struct ble_gatt_error* err, struct ble_gatt_attr* attr, void*) {
  if (err && err->status == 0 && attr && attr->om && OS_MBUF_PKTLEN(attr->om) >= 1) {
    uint8_t val = 0; os_mbuf_copydata(attr->om, 0, 1, &val);
    if (val <= 100) {
      portENTER_CRITICAL(&bleMux);
      bleHostBatVal = val; bleHostBatPending = true; bleNextBatPollMs = millis() + 60000UL; bleCtsState = CTS_DONE;
      portEXIT_CRITICAL(&bleMux); return 0;
    }
  }
  setCtsState(CTS_DONE); return 0;
}

int onBleBatChrCb(uint16_t ch, const struct ble_gatt_error* err, const struct ble_gatt_chr* chr, void*) {
  if (!err) return 0;
  if (err->status == 0 && chr) {
    if (chr->uuid.u.type == BLE_UUID_TYPE_16 && chr->uuid.u16.value == 0x2A19) { portENTER_CRITICAL(&bleMux); blePeerBatHandle = chr->val_handle; portEXIT_CRITICAL(&bleMux); }
    return 0;
  }
  portENTER_CRITICAL(&bleMux);
  if (bleClientConnected && ch == activeBleConnHandle) { bleCtsState = blePeerBatHandle ? CTS_READ_BAT : CTS_DONE; bleNextCtsProbeMs = millis() + 40UL; }
  portEXIT_CRITICAL(&bleMux); return 0;
}

int onBleBatSvcCb(uint16_t ch, const struct ble_gatt_error* err, const struct ble_gatt_svc* svc, void*) {
  if (!err) return 0;
  if (err->status == 0 && svc) { portENTER_CRITICAL(&bleMux); bleBatSvcStart = svc->start_handle; bleBatSvcEnd = svc->end_handle; portEXIT_CRITICAL(&bleMux); return 0; }
  portENTER_CRITICAL(&bleMux);
  if (bleClientConnected && ch == activeBleConnHandle) {
    if (bleBatSvcStart && bleBatSvcEnd >= bleBatSvcStart) { bleCtsState = CTS_DISC_BAT_CHR; bleNextCtsProbeMs = millis() + 40UL; }
    else bleCtsState = CTS_DONE;
  }
  portEXIT_CRITICAL(&bleMux); return 0;
}

int onBleCtsTimeReadCb(uint16_t, const struct ble_gatt_error* err, struct ble_gatt_attr* attr, void*) {
  if (!err) return 0;
  if (err->status == 0 && attr && attr->om && OS_MBUF_PKTLEN(attr->om) >= 7) {
    uint8_t b[10]; uint16_t len = min((uint16_t)10, OS_MBUF_PKTLEN(attr->om)); os_mbuf_copydata(attr->om, 0, len, b);
    uint16_t yr = (uint16_t)b[0] | ((uint16_t)b[1] << 8);
    if (yr >= 2024 && yr <= 2099 && b[2] >= 1 && b[2] <= 12 && b[3] >= 1 && b[3] <= 31 && b[4] < 24 && b[5] < 60 && b[6] < 60) {
      portENTER_CRITICAL(&bleMux);
      bleCtsLocalEpoch = DateTime(yr, b[2], b[3], b[4], b[5], b[6]).unixtime();
      bleCtsPending = true; bleCtsState = blePeerBatHandle ? CTS_READ_BAT : CTS_DISC_BAT_SVC; bleNextCtsProbeMs = millis() + 60UL;
      portEXIT_CRITICAL(&bleMux); return 0;
    }
  }
  portENTER_CRITICAL(&bleMux);
  bleCtsLastErr = err->status;
  if (bleCtsAttempt < 10) { bleCtsAttempt++; bleCtsState = CTS_READ_TIME; bleNextCtsProbeMs = millis() + 1500UL; }
  else { bleCtsState = CTS_DISC_BAT_SVC; bleNextCtsProbeMs = millis() + 60UL; bleCtsLogNoCts = true; }
  portEXIT_CRITICAL(&bleMux); return 0;
}

int onBleCtsLocalReadCb(uint16_t ch, const struct ble_gatt_error* err, struct ble_gatt_attr* attr, void*) {
  if (err && err->status == 0 && attr && attr->om && OS_MBUF_PKTLEN(attr->om) >= 1) {
    uint8_t b[4] = {0}; uint16_t len = min((uint16_t)4, OS_MBUF_PKTLEN(attr->om)); os_mbuf_copydata(attr->om, 0, len, b);
    int8_t q = (int8_t)b[0];
    if (q >= -48 && q <= 56) {
      int32_t tzm = (int32_t)q * 15 + ((len >= 2 && (b[1] == 2 || b[1] == 4 || b[1] == 8)) ? (int32_t)b[1] * 15 : 0);
      portENTER_CRITICAL(&bleMux); bleCtsTzMin = tzm; bleCtsHasTz = true; portEXIT_CRITICAL(&bleMux);
    }
  }
  portENTER_CRITICAL(&bleMux);
  if (bleClientConnected && ch == activeBleConnHandle) { bleCtsState = bleCtsTimeHandle ? CTS_READ_TIME : CTS_DONE; bleNextCtsProbeMs = millis() + 40UL; }
  portEXIT_CRITICAL(&bleMux); return 0;
}

int onBleCtsChrCb(uint16_t ch, const struct ble_gatt_error* err, const struct ble_gatt_chr* chr, void*) {
  if (!err) return 0;
  if (err->status == 0 && chr) {
    if (chr->uuid.u.type == BLE_UUID_TYPE_16) {
      portENTER_CRITICAL(&bleMux);
      if (chr->uuid.u16.value == 0x2A2B) bleCtsTimeHandle = chr->val_handle;
      else if (chr->uuid.u16.value == 0x2A0F) bleCtsLocalHandle = chr->val_handle;
      portEXIT_CRITICAL(&bleMux);
    }
    return 0;
  }
  portENTER_CRITICAL(&bleMux);
  if (bleClientConnected && ch == activeBleConnHandle) {
    if (bleCtsTimeHandle) { bleCtsState = bleCtsLocalHandle ? CTS_READ_LOCAL : CTS_READ_TIME; bleNextCtsProbeMs = millis() + 40UL; }
    else { bleCtsLastErr = err->status; bleCtsState = CTS_DONE; bleCtsLogNoCts = true; }
  }
  portEXIT_CRITICAL(&bleMux); return 0;
}

int onBleCtsSvcCb(uint16_t ch, const struct ble_gatt_error* err, const struct ble_gatt_svc* svc, void*) {
  if (!err) return 0;
  if (err->status == 0 && svc) { portENTER_CRITICAL(&bleMux); bleCtsSvcStart = svc->start_handle; bleCtsSvcEnd = svc->end_handle; portEXIT_CRITICAL(&bleMux); return 0; }
  portENTER_CRITICAL(&bleMux);
  if (bleClientConnected && ch == activeBleConnHandle) {
    if (bleCtsSvcStart && bleCtsSvcEnd >= bleCtsSvcStart) { bleCtsState = CTS_DISC_CHR; bleCtsLogFound = true; bleNextCtsProbeMs = millis() + 40UL; }
    else {
      bleCtsLastErr = err->status;
      if (bleCtsAttempt < 10) { bleCtsAttempt++; bleCtsState = CTS_DISC_SVC; bleNextCtsProbeMs = millis() + 2500UL; }
      else { bleCtsState = CTS_DISC_BAT_SVC; bleNextCtsProbeMs = millis() + 60UL; bleCtsLogNoCts = true; }
    }
  }
  portEXIT_CRITICAL(&bleMux); return 0;
}

void startBleAdvertising() {
  NimBLEAdvertising* adv = NimBLEDevice::getAdvertising();
  adv->setAdvertisementData(bleAdvData); adv->setScanResponseData(bleScanData);
  adv->setScanResponse(true); adv->start();
}

class DinoBleServerCb : public NimBLEServerCallbacks {
  void onConnect(NimBLEServer*, ble_gap_conn_desc* desc) override {
    portENTER_CRITICAL(&bleMux);
    bleClientConnected = true; activeBleConnHandle = desc->conn_handle; bleConnAtMs = millis();
    bleCtsEncrypted = (desc->sec_state.encrypted != 0); bleCtsSecStarted = bleCtsEncrypted;
    bleGotDirectCmd = bleHostBatValid = bleHostBatPending = false;
    bleCtsSvcStart = bleCtsSvcEnd = bleCtsTimeHandle = bleCtsLocalHandle = 0;
    bleBatSvcStart = bleBatSvcEnd = blePeerBatHandle = 0;
    bleNextBatPollMs = bleCtsAttempt = bleCtsLastErr = 0; bleCtsHasTz = false;
    bleCtsLogFound = bleCtsLogNoCts = false; bleCtsLogAuth = bleCtsEncrypted;
    bleCtsState = bleCtsEncrypted ? CTS_DISC_SVC : CTS_WAIT_SEC;
    bleNextCtsProbeMs = bleConnAtMs + (bleCtsEncrypted ? 450UL : 500UL);
    portEXIT_CRITICAL(&bleMux);
  }
  void onAuthenticationComplete(ble_gap_conn_desc* desc) override {
    if (!desc->sec_state.encrypted) return;
    portENTER_CRITICAL(&bleMux);
    bleCtsEncrypted = bleCtsSecStarted = bleSvcChangedPending = bleCtsLogAuth = true;
    bleCtsAttempt = bleCtsSvcStart = bleCtsSvcEnd = bleCtsTimeHandle = bleCtsLocalHandle = 0;
    bleCtsState = CTS_DISC_SVC; bleNextCtsProbeMs = millis() + 450UL;
    portEXIT_CRITICAL(&bleMux);
  }
  void onDisconnect(NimBLEServer*) override {
    portENTER_CRITICAL(&bleMux);
    bleClientConnected = bleCtsEncrypted = bleCtsSecStarted = bleHostBatPending = bleHostBatValid = false;
    blePeerBatHandle = bleNextBatPollMs = 0; bleCtsState = CTS_IDLE; bleNextCtsProbeMs = 0;
    portEXIT_CRITICAL(&bleMux);
    startBleAdvertising();
  }
} dinoBleServerCb;

class DinoBleCharCb : public NimBLECharacteristicCallbacks {
  void onRead(NimBLECharacteristic* c) override { c->setValue(buildStatusJson().c_str()); }
  void onWrite(NimBLECharacteristic* c) override {
    std::string v = c->getValue(); if (v.empty()) return;
    portENTER_CRITICAL(&bleMux);
    size_t n = min(v.size(), sizeof(bleCmdBuf) - 1); memcpy(bleCmdBuf, v.data(), n); bleCmdBuf[n] = '\0'; bleCmdPending = true;
    portEXIT_CRITICAL(&bleMux);
  }
} dinoBleCharCb;

static const char PORTAL_HTML[] PROGMEM = R"rawliteral(<!DOCTYPE html><html><head><meta charset="utf-8"><meta name="viewport" content="width=device-width,initial-scale=1"><title>DINO KEY Setup</title><style>*{box-sizing:border-box;font-family:monospace}body{margin:0;padding:16px;background:#000;color:#fff;max-width:460px;margin:auto}h1{font-size:20px;margin:0 0 4px}.sub{font-size:12px;color:#aaa;margin-bottom:14px}.card{border:1px solid #444;border-radius:10px;padding:12px;margin-bottom:12px;background:#0a0a0a}.row{display:flex;justify-content:space-between;font-size:13px;margin:4px 0}.k{color:#999}.v{font-weight:bold;color:#fff}button,input,select{width:100%;padding:10px;margin-top:6px;border-radius:8px;border:1px solid #555;background:#141414;color:#fff;font-size:13px}button{background:#fff;color:#000;font-weight:bold;cursor:pointer;border:none}button.alt{background:#1c1c1c;color:#fff;border:1px solid #555}.net{padding:8px;margin-top:6px;border:1px solid #333;border-radius:6px;cursor:pointer;display:flex;justify-content:space-between;font-size:12px}.net:hover{border-color:#fff}.msg{font-size:12px;color:#0f0;margin-top:6px;min-height:16px}.tip{font-size:11px;color:#aaa;margin-top:6px;line-height:1.4}</style></head><body><h1>DINO KEY v1.0</h1><div class="sub">Clock Sync • 2.4GHz Wi-Fi • BLE Control</div><div class="card"><div class="row"><span class="k">Clock</span><span class="v" id="tm">--</span></div><div class="row"><span class="k">Time Source</span><span class="v" id="src">--</span></div><div class="row"><span class="k">Saved Wi-Fi</span><span class="v" id="st">--</span></div><div class="row"><span class="k">BLE ("DINO KEY")</span><span class="v" id="bl">Advertising</span></div><button onclick="syncNow()">Sync Time Now</button><div class="msg" id="smsg">Syncing phone/Mac clock...</div></div><div class="card"><div class="k">2.4 GHz Wi-Fi Setup</div><button class="alt" onclick="scanWifi()">Scan 2.4 GHz Networks</button><div id="nets"></div><select id="slot"><option value="1">Slot 1 (Router Wi-Fi)</option><option value="2">Slot 2 (Phone Hotspot)</option></select><input id="ssid" placeholder="Wi-Fi Name (SSID)"><input id="pass" type="password" placeholder="Password (blank if open)"><button onclick="saveWifi()">Save Wi-Fi &amp; Connect</button><button class="alt" onclick="clearWifi()">Forget Saved Wi-Fi</button><div class="msg" id="wmsg"></div><div class="tip">Tip: On iPhone Hotspot, enable <b>Maximize Compatibility</b> (2.4 GHz).</div></div><div class="card"><div class="k">Quick Screen Control</div><div style="display:grid;grid-template-columns:1fr 1fr;gap:6px"><button class="alt" onclick="cmd('mode=0')">HOME</button><button class="alt" onclick="cmd('mode=1')">CLOCK</button><button class="alt" onclick="cmd('mode=2')">STOPWATCH</button><button class="alt" onclick="cmd('mode=4')">DINO RUN</button><button class="alt" onclick="cmd('mode=7')">BRIGHTNESS</button><button class="alt" onclick="cmd('mode=5')">FULL FACE</button></div><div class="k" style="margin-top:10px">Brightness (1-5)</div><div style="display:grid;grid-template-columns:repeat(5,1fr);gap:4px"><button class="alt" onclick="cmd('bri=1')">1</button><button class="alt" onclick="cmd('bri=2')">2</button><button class="alt" onclick="cmd('bri=3')">3</button><button class="alt" onclick="cmd('bri=4')">4</button><button class="alt" onclick="cmd('bri=5')">5</button></div><div style="display:grid;grid-template-columns:1fr 1fr;gap:6px;margin-top:6px"><button class="alt" onclick="cmd('sw=toggle')">SW Start/Stop</button><button class="alt" onclick="cmd('sw=reset')">SW Reset</button></div></div><script>const $=id=>document.getElementById(id);async function refresh(){try{const d=await(await fetch('/api/status')).json();$('tm').textContent=d.date+' '+d.time;$('src').textContent=d.sync+(d.live?'':' (offline)');$('st').textContent=d.wifi+(d.staIp?' ('+d.staIp+')':'');$('bl').textContent=d.bleConn?'Connected':'Ready ("DINO KEY")';if(d.ssid1&&!$('ssid').value)$('ssid').value=d.ssid1;}catch(e){}}async function syncNow(){try{const r=await fetch('/api/sync?utc='+Math.floor(Date.now()/1000)+'&tzmin='+(-new Date().getTimezoneOffset()));$('smsg').textContent=await r.text();refresh();}catch(e){$('smsg').textContent='Sync error';}}async function scanWifi(){const el=$('nets');el.innerHTML='<div class="tip">Scanning...</div>';try{const list=await(await fetch('/api/scan')).json();el.innerHTML=list.length?'':'<div class="tip">No 2.4GHz networks found.</div>';list.forEach(n=>{const d=document.createElement('div');d.className='net';d.innerHTML='<span>'+n.ssid+'</span><span>'+n.rssi+' dBm</span>';d.onclick=()=>{$('ssid').value=n.ssid;};el.appendChild(d);});}catch(e){el.innerHTML='<div class="tip">Scan failed</div>';}}async function saveWifi(){const body=new URLSearchParams({slot:$('slot').value,ssid:$('ssid').value,pass:$('pass').value});$('wmsg').textContent=await(await fetch('/api/wifi',{method:'POST',body})).text();setTimeout(refresh,1500);}async function clearWifi(){$('wmsg').textContent=await(await fetch('/api/clearwifi')).text();refresh();}async function cmd(q){try{await fetch('/api/cmd?'+q);refresh();}catch(e){}}syncNow();setInterval(syncNow,5000);setInterval(refresh,3000);</script></body></html>)rawliteral";

void setupConnectivity() {
  NimBLEDevice::init(BLE_NAME);
  NimBLEDevice::setSecurityAuth(true, false, true);
  NimBLEDevice::setSecurityIOCap(BLE_HS_IO_NO_INPUT_OUTPUT);
  NimBLEDevice::setSecurityInitKey(BLE_SM_PAIR_KEY_DIST_ENC | BLE_SM_PAIR_KEY_DIST_ID);
  NimBLEDevice::setSecurityRespKey(BLE_SM_PAIR_KEY_DIST_ENC | BLE_SM_PAIR_KEY_DIST_ID);

  bleServer = NimBLEDevice::createServer();
  bleServer->advertiseOnDisconnect(false);
  bleServer->setCallbacks(&dinoBleServerCb);

  bleHid = new NimBLEHIDDevice(bleServer);
  bleHid->manufacturer("Anagh Kolte");
  bleHid->pnp(0x02, 0xE502, 0xA111, 0x0100);
  bleHid->hidInfo(0x00, 0x02);
  bleHid->reportMap((uint8_t*)DINO_HID_REPORT_MAP, sizeof(DINO_HID_REPORT_MAP));
  bleHidInput = bleHid->inputReport(1);
  uint8_t z = 0; bleHidInput->setValue(&z, 1);
  bleHid->setBatteryLevel(100);
  bleBatChar = bleHid->batteryLevel();

  NimBLEService* syncSvc = bleServer->createService(DINO_BLE_SERVICE_UUID);
  bleCmdChar = syncSvc->createCharacteristic(DINO_BLE_CHAR_UUID,
    NIMBLE_PROPERTY::READ | NIMBLE_PROPERTY::WRITE | NIMBLE_PROPERTY::WRITE_NR | NIMBLE_PROPERTY::NOTIFY);
  bleCmdChar->setCallbacks(&dinoBleCharCb);
  bleHid->startServices(); syncSvc->start();

  bleAdvData = NimBLEAdvertisementData();
  bleAdvData.setFlags(BLE_HS_ADV_F_DISC_GEN | BLE_HS_ADV_F_BREDR_UNSUP);
  bleAdvData.setAppearance(GENERIC_HID);
  bleAdvData.setCompleteServices16({NimBLEUUID((uint16_t)0x1812), NimBLEUUID((uint16_t)0x180F)});
  const uint8_t solCts[4] = {0x03, BLE_HS_ADV_TYPE_SOL_UUIDS16, 0x05, 0x18};
  bleAdvData.addData(std::string((const char*)solCts, sizeof(solCts)));
  bleAdvData.setName(BLE_NAME);

  bleScanData = NimBLEAdvertisementData();
  bleScanData.setCompleteServices(NimBLEUUID(DINO_BLE_SERVICE_UUID));
  bleScanData.setName(BLE_NAME);
  NimBLEDevice::getAdvertising()->setMinPreferred(0x06);
  NimBLEDevice::getAdvertising()->setMaxPreferred(0x12);
  startBleAdvertising();

  WiFi.mode(WIFI_AP_STA);
  bool apOk = WiFi.softAP(AP_SSID, nullptr, 1, 0, 4);
  delay(100);
  WiFi.setTxPower(WIFI_POWER_13dBm);
  WiFi.setAutoReconnect(true);
  WiFi.onEvent([](WiFiEvent_t ev, WiFiEventInfo_t info) {
    if (ev == ARDUINO_EVENT_WIFI_STA_DISCONNECTED) {
      uint8_t r = info.wifi_sta_disconnected.reason;
      lastWifiErr = (r == 201) ? "NoSSID/5GHz?" : (r == 202 || r == 15 || r == 2) ? "BadPass" : ("Err" + String(r));
    } else if (ev == ARDUINO_EVENT_WIFI_STA_GOT_IP) lastWifiErr = "";
  });

  dnsServer.setErrorReplyCode(DNSReplyCode::NoError);
  dnsServer.start(53, "*", WiFi.softAPIP());
  auto sendPortal = []() { server.send_P(200, "text/html", PORTAL_HTML); };
  static const char* paths[] = {"/", "/hotspot-detect.html", "/library/test/success.html", "/generate_204", "/gen_204", "/connecttest.txt", "/ncsi.txt"};
  for (const char* p : paths) server.on(p, HTTP_GET, sendPortal);
  server.on("/api/status", HTTP_GET, []() { server.send(200, "application/json", buildStatusJson()); });
  server.on("/api/sync", HTTP_GET, []() {
    if (server.hasArg("utc")) {
      uint32_t utc = (uint32_t)strtoul(server.arg("utc").c_str(), nullptr, 10);
      int32_t tzm = server.hasArg("tzmin") ? (int32_t)atol(server.arg("tzmin").c_str()) : tzOffsetMin;
      if (utc > 1700000000UL) {
        applyUtcAndTz(utc, tzm, "WEB");
        char ts[16], ds[20]; formatDateStr(ds, sizeof(ds)); formatTimeStr(ts, sizeof(ts), false);
        server.send(200, "text/plain", String("Synced: ") + ds + " " + ts); return;
      }
    }
    server.send(400, "text/plain", "Missing utc");
  });
  server.on("/api/scan", HTTP_GET, []() {
    WiFi.disconnect(false);
    int n = WiFi.scanNetworks(false, false);
    String out = "[";
    for (int i = 0; i < n && i < 12; i++) {
      String s = WiFi.SSID(i); s.replace("\"", "");
      out += String(i > 0 ? "," : "") + "{\"ssid\":\"" + s + "\",\"rssi\":" + String(WiFi.RSSI(i)) + "}";
    }
    out += "]";
    WiFi.scanDelete();
    if (hasAnyWifiConfigured()) wifiState = STA_IDLE;
    server.send(200, "application/json", out);
  });
  server.on("/api/wifi", HTTP_POST, []() {
    int slot = server.hasArg("slot") ? server.arg("slot").toInt() : 1;
    String ssid = server.arg("ssid"), pass = server.arg("pass"); ssid.trim();
    if (ssid.length() == 0) { server.send(400, "text/plain", "SSID required"); return; }
    saveWifiCredentials(slot, ssid, pass);
    server.send(200, "text/plain", "Saved '" + ssid + "'. Connecting...");
  });
  server.on("/api/clearwifi", HTTP_GET, []() { clearWifiCredentials(); server.send(200, "text/plain", "Saved Wi-Fi cleared."); });
  server.on("/api/cmd", HTTP_GET, []() {
    if (server.hasArg("mode")) { int m = server.arg("mode").toInt(); if (m >= 0 && m < 8) currentMode = (ScreenMode)m; }
    if (server.hasArg("face")) { int f = server.arg("face").toInt(); if (f >= 0 && f < 20) faceIdx = f; }
    if (server.hasArg("bri")) setBrightnessLevel((uint8_t)server.arg("bri").toInt(), true);
    if (server.hasArg("sw")) { String sw = server.arg("sw"); if (sw == "toggle") toggleStopwatch(); else if (sw == "reset") resetStopwatch(); }
    if (server.hasArg("bat")) {
      int b = server.arg("bat").toInt();
      if (b >= 0 && b <= 100) { bleHostBatPct = (float)b; bleHostBatCharging = server.arg("chg").toInt() != 0; bleHostBatValid = true; }
    }
    server.send(200, "text/plain", "OK");
  });
  server.onNotFound([]() { server.sendHeader("Location", "http://192.168.4.1/", true); server.send(302, "text/plain", ""); });
  server.begin();
  if (MDNS.begin("dinokey")) MDNS.addService("http", "tcp", 80);
  Serial.printf("[WIFI] AP %s (ok=%d) http://%s\n", AP_SSID, apOk ? 1 : 0, WiFi.softAPIP().toString().c_str());
}

bool syncTimeViaHttpDate() {
  static const char* hosts[] = {"captive.apple.com", "clients3.google.com"};
  static const char* paths[] = {"/hotspot-detect.html", "/generate_204"};
  for (int i = 0; i < 2; i++) {
    WiFiClient c; c.setTimeout(1500);
    if (!c.connect(hosts[i], 80)) continue;
    c.print(String("HEAD ") + paths[i] + " HTTP/1.0\r\nHost: " + hosts[i] + "\r\nConnection: close\r\n\r\n");
    unsigned long t0 = millis();
    while (c.connected() && !c.available() && (millis() - t0 < 1500UL)) delay(5);
    while (c.available()) {
      String line = c.readStringUntil('\n'); line.trim();
      if (line.startsWith("Date:") || line.startsWith("date:")) {
        char mon[8] = {0}; int d, y, hh, mm, ss;
        const char* p = strchr(line.c_str(), ',');
        if (p && sscanf(p + 1, " %d %3s %d %d:%d:%d", &d, mon, &y, &hh, &mm, &ss) == 6 && y >= 2024) {
          const char* mos = "JanFebMarAprMayJunJulAugSepOctNovDec";
          if (const char* f = strstr(mos, mon)) {
            c.stop();
            applyUtcAndTz(DateTime(y, (int)((f - mos) / 3) + 1, d, hh, mm, ss).unixtime(), tzOffsetMin, "NET");
            return true;
          }
        }
      }
      if (line.length() == 0) break;
    }
    c.stop();
  }
  return false;
}

void wifiAndNtpTick() {
#if ENABLE_WIFI_NTP
  unsigned long now = millis();
  if (WiFi.status() == WL_CONNECTED) {
    if (wifiState != STA_CONNECTED) {
      wifiState = STA_CONNECTED; staConnectedAtMs = now; lastHttpTimeTryMs = lastNtpSyncMs = 0;
      if (!sntpStarted) { configTime(0, 0, "pool.ntp.org", "time.google.com", "time.apple.com"); sntpStarted = true; }
    }
    if (time(nullptr) > 1700000000) {
      if (!ntpSynced || (now - lastNtpSyncMs >= 1800000UL)) {
        ntpSynced = true; lastNtpSyncMs = now;
        applyUtcAndTz((uint32_t)time(nullptr), tzOffsetMin, "NTP");
        updateBleStatusValue(true);
      }
    } else if ((!timeSyncedLive || timeSource == "NVS" || timeSource == "EST") &&
               (now - staConnectedAtMs >= 3000UL) && (!lastHttpTimeTryMs || (now - lastHttpTimeTryMs >= 15000UL))) {
      lastHttpTimeTryMs = now;
      if (syncTimeViaHttpDate()) { ntpSynced = true; lastNtpSyncMs = now; updateBleStatusValue(true); }
    }
    return;
  }
  if (wifiState == STA_CONNECTED) { wifiState = STA_COOLDOWN; wifiStateMs = now; }
  if (!hasAnyWifiConfigured()) { wifiState = STA_IDLE; return; }
  if (wifiState == STA_IDLE) {
    String s, p;
    for (int i = 0; i < 3; i++) {
      if (getSlotCreds(wifiActiveSlot, s, p)) { activeStaSsid = s; WiFi.begin(s.c_str(), p.c_str()); wifiState = STA_CONNECTING; wifiStateMs = now; return; }
      wifiActiveSlot = (wifiActiveSlot + 1) % 3;
    }
  } else if (wifiState == STA_CONNECTING && (now - wifiStateMs >= 12000UL)) {
    WiFi.disconnect(false); wifiActiveSlot = (wifiActiveSlot + 1) % 3;
    wifiState = (wifiActiveSlot == 0) ? STA_COOLDOWN : STA_IDLE; wifiStateMs = now;
  } else if (wifiState == STA_COOLDOWN && (now - wifiStateMs >= 45000UL)) {
    wifiActiveSlot = 0; wifiState = STA_IDLE;
  }
#endif
}

void updateSensors() {
  unsigned long now = millis();
  if (now - lastSoftTickMs >= 1000UL) {
    uint32_t d = (now - lastSoftTickMs) / 1000UL;
    softEpochSaved += d; lastSoftTickMs += d * 1000UL;
  }
  if (now - lastNvsSaveMs >= 60000UL) { lastNvsSaveMs = now; prefs.putULong("epoch", softEpochSaved); }
  if (now - lastRtcPoll >= 1000) {
    lastRtcPoll = now;
    if (rtcAvailable) {
      cachedNow = rtc.now(); softEpochSaved = cachedNow.unixtime(); timeSyncedLive = true;
      if (timeSource != "NTP" && timeSource != "BLE" && timeSource != "WEB") timeSource = "RTC";
    } else {
      if (now - lastHwRetryMs >= 10000UL) { lastHwRetryMs = now; rtcAvailable = rtc.begin(); }
      cachedNow = rtcAvailable ? rtc.now() : DateTime(softEpochSaved);
    }
  }
  if (now - lastBatPoll >= 5000) {
    lastBatPoll = now;
    if (batteryAvailable) {
      float p = maxlipo.cellPercent(), v = maxlipo.cellVoltage(); batChargeRate = maxlipo.chargeRate();
      if (!isnan(p) && p >= 0.0f && p <= 150.0f) {
        batPercent = constrain(p, 0.0f, 100.0f); batVoltage = v;
        if (bleClientConnected && (uint8_t)batPercent != lastBleBatSent) updateBleStatusValue(true);
      } else batteryAvailable = maxlipo.begin();
    } else batteryAvailable = maxlipo.begin();
  }
}

void renderHome() {
  char ds[20], ts[16], bs[10];
  formatDateStr(ds, sizeof(ds)); formatTimeStr(ts, sizeof(ts), false);
  u8g2.setFont(u8g2_font_5x7_tf);
  u8g2.drawStr(2, 7, ds); u8g2.drawStr(2, 15, ts);

  bool hasBat, fromBle, chg; float pct; getBatInfo(hasBat, pct, fromBle, chg);
  if (hasBat) snprintf(bs, sizeof(bs), "%.0f%%", pct); else strcpy(bs, "--%");
  bool hide = false;
  if (batteryAvailable && batPercent <= 5.0f) {
    if (millis() - critFlashMs >= 400) { critFlash = !critFlash; critFlashMs = millis(); }
    hide = critFlash;
  }
  if (!hide) {
    const int bx = 110, by = 4, bw = 14, bh = 8;
    u8g2.drawStr(bx - u8g2.getStrWidth(bs) - 2, 11, bs);
    u8g2.drawFrame(bx, by, bw, bh); u8g2.drawBox(bx + bw, by + 2, 2, 4);
    if (hasBat) { int fw = (int)((bw - 4) * pct / 100.0f); if (fw > 0) u8g2.drawBox(bx + 2, by + 2, fw, bh - 4); }
  }
  u8g2.drawHLine(0, 17, 128);
  drawFaceFromTable(isBlinking ? FACE_SLEEPY_IDX : faceIdx, false);
}

void renderClock() {
  bool hasBat, fromBle, chg; float pct; getBatInfo(hasBat, pct, fromBle, chg);
  char bs[8], bigTime[16], ds[24];
  if (hasBat) snprintf(bs, sizeof(bs), "%.0f%%", pct); else strcpy(bs, "--%");
  u8g2.setFont(u8g2_font_6x10_tf); u8g2.drawStr(2, 9, "DINO CLOCK");
  u8g2.drawStr(126 - u8g2.getStrWidth(bs), 9, bs);
  u8g2.setFont(u8g2_font_5x7_tf); u8g2.drawStr(69, 8, timeSource.c_str());
  u8g2.drawHLine(0, 11, 128);

  formatTimeStr(bigTime, sizeof(bigTime), true);
  u8g2.setFont(u8g2_font_logisoso18_tn);
  u8g2.drawStr((128 - u8g2.getStrWidth(bigTime)) / 2, 36, bigTime);
  if (DEFAULT_12H_FORMAT) { u8g2.setFont(u8g2_font_5x7_tf); u8g2.drawStr(111, 36, cachedNow.hour() >= 12 ? "PM" : "AM"); }
  formatDateStr(ds, sizeof(ds));
  u8g2.setFont(u8g2_font_6x10_tf);
  u8g2.drawStr((128 - u8g2.getStrWidth(ds)) / 2, 50, ds);
  u8g2.drawRBox(54, 56, 8, 5, 1); u8g2.drawRBox(66, 56, 8, 5, 1);
}

void renderBattery() {
  u8g2.setFont(u8g2_font_6x10_tf); u8g2.drawStr(2, 9, "POWER DIAGNOSTICS"); u8g2.drawHLine(0, 11, 128);
  bool hasBat, fromBle, chg; float pct;
  if (!getBatInfo(hasBat, pct, fromBle, chg)) {
    u8g2.drawStr(10, 32, "No battery sensor");
    u8g2.setFont(u8g2_font_5x7_tf); u8g2.drawStr(10, 46, "Pair Bluetooth to sync");
    return;
  }
  char pctStr[8]; snprintf(pctStr, sizeof(pctStr), "%.0f", pct);
  u8g2.setFont(u8g2_font_logisoso18_tn); u8g2.drawStr(24, 32, pctStr);
  u8g2.setFont(u8g2_font_6x10_tf); u8g2.drawStr(56, 24, "%");
  if (fromBle) {
    u8g2.drawStr(74, 24, "VIA BLE");
    u8g2.drawStr(74, 34, chg ? "CHARGING" : (pct <= 20.0f ? "LOW BAT" : "BT LINKED"));
  } else {
    char vs[16]; snprintf(vs, sizeof(vs), "%.2f V", batVoltage);
    u8g2.drawStr(78, 24, vs);
    u8g2.drawStr(78, 34, chg ? "CHARGING" : (pct <= 20.0f ? "LOW BAT" : "HEALTHY"));
  }
  u8g2.drawFrame(10, 42, 104, 14); u8g2.drawBox(114, 46, 4, 6);
  int fw = (int)(98.0f * pct / 100.0f); if (fw > 0) u8g2.drawBox(13, 45, fw, 8);
  u8g2.setFont(u8g2_font_5x7_tf);
  u8g2.drawStr(12, 62, fromBle ? "BLUETOOTH BATTERY SYNC" : "MAX17048 LI-ION FUEL GAUGE");
}

void renderDino() {
  char buf[24];
  u8g2.drawHLine(0, GROUND_Y, 128);
  for (int gx = -((int)groundShift % 16); gx < 128; gx += 16) u8g2.drawPixel(gx + 5, GROUND_Y + 3);
  u8g2.setFont(u8g2_font_5x7_tf);
  snprintf(buf, sizeof(buf), "HI %05lu  %05lu", (unsigned long)dinoBest, (unsigned long)dinoScore);
  u8g2.drawStr(128 - u8g2.getStrWidth(buf) - 1, 7, buf);
  if (dinoPlaying) {
    drawDinoStep(DINO_X, GROUND_Y - DINO_H - (int)dinoY, (dinoY <= 0.0f) && ((millis() / 100) % 2));
    for (int i = 0; i < 2; i++) if (cacti[i].x < 128) {
      int x = (int)cacti[i].x; u8g2.drawBox(x, GROUND_Y - cacti[i].h, cacti[i].w, cacti[i].h);
      if (cacti[i].h > 10) { u8g2.drawBox(x - 2, GROUND_Y - cacti[i].h + 4, 2, 3); u8g2.drawBox(x + cacti[i].w, GROUND_Y - cacti[i].h + 2, 2, 3); }
    }
  } else {
    drawDinoStep(DINO_X, GROUND_Y - DINO_H, false);
    u8g2.setFont(u8g2_font_7x14B_tf);
    const char* t = dinoOverAt ? "GAME OVER" : "DINO RUN";
    u8g2.drawStr((128 - u8g2.getStrWidth(t)) / 2, 28, t);
    u8g2.setFont(u8g2_font_5x7_tf);
    const char* h = "2x click: play";
    u8g2.drawStr((128 - u8g2.getStrWidth(h)) / 2, 42, h);
  }
}

void renderFullFace() {
  u8g2.drawHLine(2, 2, 8);   u8g2.drawVLine(2, 2, 8);
  u8g2.drawHLine(118, 2, 8); u8g2.drawVLine(125, 2, 8);
  u8g2.drawHLine(2, 61, 8);  u8g2.drawVLine(2, 54, 8);
  u8g2.drawHLine(118, 61, 8);u8g2.drawVLine(125, 54, 8);
  drawFaceFromTable(isBlinking ? FACE_SLEEPY_IDX : faceIdx, true);
}

void renderConnect() {
  u8g2.setFont(u8g2_font_6x10_tf); u8g2.drawStr(2, 9, "WIFI & BT SYNC");
  u8g2.setFont(u8g2_font_5x7_tf); u8g2.drawStr(126 - u8g2.getStrWidth(timeSource.c_str()), 8, timeSource.c_str());
  u8g2.drawHLine(0, 11, 128);
  char line[32], ts[16];
  if (WiFi.status() == WL_CONNECTED) {
    snprintf(line, sizeof(line), "WF:%s", activeStaSsid.c_str()); line[21] = '\0'; u8g2.drawStr(2, 22, line);
    snprintf(line, sizeof(line), "IP:%s", WiFi.localIP().toString().c_str()); u8g2.drawStr(2, 31, line);
  } else {
    if (lastWifiErr.length() > 0 && hasAnyWifiConfigured()) snprintf(line, sizeof(line), "WF:%s", lastWifiErr.c_str());
    else snprintf(line, sizeof(line), "%s", hasAnyWifiConfigured() ? "WF:Connecting/Retry" : "WF:Not saved yet");
    u8g2.drawStr(2, 22, line); u8g2.drawStr(2, 31, "AP:DINO-KEY 192.168.4.1");
  }
  snprintf(line, sizeof(line), "BT:%s", bleClientConnected ? "DINO KEY (LINKED)" : "DINO KEY (READY)");
  u8g2.drawStr(2, 42, line);
  formatTimeStr(ts, sizeof(ts), false);
  snprintf(line, sizeof(line), "TM:%s [%s]", ts, timeSyncedLive ? "SYNCED" : "OFFLINE");
  u8g2.drawStr(2, 52, line); u8g2.drawStr(2, 62, "2x click: Retry Wi-Fi");
}

void renderStopwatch() {
  u8g2.setFont(u8g2_font_6x10_tf); u8g2.drawStr(2, 9, "STOPWATCH");
  u8g2.setFont(u8g2_font_5x7_tf);
  const char* st = swRunning ? "RUN" : (swAccumMs > 0 ? "PAUSED" : "READY");
  u8g2.drawStr(126 - u8g2.getStrWidth(st), 8, st); u8g2.drawHLine(0, 11, 128);
  uint32_t ms = getStopwatchMs(), tot = ms / 1000UL, d = (ms % 1000UL) / 100UL;
  uint32_t mins = (tot / 60UL) % 60UL, hrs = tot / 3600UL, secs = tot % 60UL;
  char mainStr[12];
  if (hrs > 0) snprintf(mainStr, sizeof(mainStr), "%02lu:%02lu:%02lu", (unsigned long)hrs, (unsigned long)mins, (unsigned long)secs);
  else snprintf(mainStr, sizeof(mainStr), "%02lu:%02lu", (unsigned long)mins, (unsigned long)secs);
  u8g2.setFont(u8g2_font_logisoso18_tn); int mw = u8g2.getStrWidth(mainStr);
  if (hrs == 0) {
    char dec[4]; snprintf(dec, sizeof(dec), ".%lu", (unsigned long)d);
    int sx = (128 - (mw + 16)) / 2; u8g2.drawStr(sx, 40, mainStr);
    u8g2.setFont(u8g2_font_6x10_tf); u8g2.drawStr(sx + mw + 2, 40, dec);
  } else u8g2.drawStr((128 - mw) / 2, 40, mainStr);
  u8g2.setFont(u8g2_font_5x7_tf); u8g2.drawStr(4, 62, "2x:Start/Stop  Hold:Reset");
}

void renderBrightness() {
  u8g2.setFont(u8g2_font_6x10_tf); u8g2.drawStr(2, 9, "BRIGHTNESS");
  u8g2.setFont(u8g2_font_5x7_tf);
  char lv[10]; snprintf(lv, sizeof(lv), "LVL %u/5", (unsigned)brightnessLevel);
  u8g2.drawStr(126 - u8g2.getStrWidth(lv), 8, lv); u8g2.drawHLine(0, 11, 128);
  for (uint8_t i = 0; i < 5; i++) {
    if (i < brightnessLevel) u8g2.drawBox(14 + i * 21, 22, 16, 18);
    else u8g2.drawFrame(14 + i * 21, 22, 16, 18);
  }
  char pct[16]; snprintf(pct, sizeof(pct), "%u%%", (unsigned)(brightnessLevel * 20));
  u8g2.setFont(u8g2_font_6x10_tf); u8g2.drawStr((128 - u8g2.getStrWidth(pct)) / 2, 51, pct);
  u8g2.setFont(u8g2_font_5x7_tf); u8g2.drawStr(12, 62, "2x click: Adjust (1-5)");
}

void renderSleep() {
  drawFaceFromTable(FACE_SLEEPING_IDX, true);
  u8g2.setFont(u8g2_font_5x7_tf);
  u8g2.drawStr(92, 18, "z"); u8g2.drawStr(100, 12, "Z");
  u8g2.drawStr(18, 60, "PRESS TO WAKE (3M SLEEP)");
}

void processBleQueue() {
  if (bleCmdPending) {
    char buf[192];
    portENTER_CRITICAL(&bleMux); strncpy(buf, bleCmdBuf, sizeof(buf) - 1); buf[sizeof(buf) - 1] = '\0'; bleCmdPending = false; portEXIT_CRITICAL(&bleMux);
    executeSyncCommand(String(buf), "BLE");
  }
  if (bleSvcChangedPending && bleClientConnected) { bleSvcChangedPending = false; ble_svc_gatt_changed(0x0001, 0xffff); }
  if (bleCtsLogAuth) { bleCtsLogAuth = false; Serial.println(F("[BLE] Paired -> discovering CTS (0x1805)")); }
  if (bleCtsLogFound) { bleCtsLogFound = false; Serial.printf("[BLE:CTS] Found 0x1805 %u..%u\n", bleCtsSvcStart, bleCtsSvcEnd); }
  if (bleCtsLogNoCts) { bleCtsLogNoCts = false; Serial.printf("[BLE:CTS] No peer CTS (err=%d)\n", bleCtsLastErr); }
  if (bleCtsPending) {
    portENTER_CRITICAL(&bleMux); uint32_t ep = bleCtsLocalEpoch; int32_t tzm = bleCtsTzMin; bool hz = bleCtsHasTz; bleCtsPending = false; portEXIT_CRITICAL(&bleMux);
    if (ep > 1700000000UL) {
      if (hz) tzOffsetMin = tzm;
      setLocalEpoch(ep, "BLE", true, true);
      updateBleStatusValue(true);
    }
  }
  if (bleHostBatPending) {
    portENTER_CRITICAL(&bleMux); uint8_t bv = bleHostBatVal; bleHostBatPending = false; portEXIT_CRITICAL(&bleMux);
    if (bv <= 100) { bleHostBatPct = (float)bv; bleHostBatCharging = false; bleHostBatValid = true; updateBleStatusValue(true); }
  }
  unsigned long now = millis();
  if (bleClientConnected && bleCtsState == CTS_DONE && blePeerBatHandle && !batteryAvailable && bleNextBatPollMs && now >= bleNextBatPollMs) {
    bleNextBatPollMs = now + 60000UL; setCtsState(CTS_READ_BAT_WAIT);
    ble_gattc_read(activeBleConnHandle, blePeerBatHandle, onBleBatReadCb, nullptr);
  }
  if (bleClientConnected && bleCtsState != CTS_IDLE && bleCtsState != CTS_DONE && bleNextCtsProbeMs && now >= bleNextCtsProbeMs) {
    BleCtsState st = bleCtsState; uint16_t ch = activeBleConnHandle;
    if (st == CTS_WAIT_SEC && !bleGotDirectCmd) {
      if (!bleCtsSecStarted) { bleCtsSecStarted = true; NimBLEDevice::startSecurity(ch); bleNextCtsProbeMs = now + 900UL; }
      else {
        ble_gap_conn_desc d;
        if (ble_gap_conn_find(ch, &d) == 0 && d.sec_state.encrypted) { bleCtsEncrypted = true; bleCtsAttempt = 0; setCtsState(CTS_DISC_SVC, 350UL); }
        else if (now - bleConnAtMs >= 10000UL && bleCtsAttempt == 0) setCtsState(CTS_DISC_SVC, 50UL);
        else bleNextCtsProbeMs = now + 1000UL;
      }
    } else if (st == CTS_DISC_SVC && !bleGotDirectCmd) {
      static const ble_uuid16_t u = BLE_UUID16_INIT(0x1805);
      portENTER_CRITICAL(&bleMux); bleCtsState = CTS_DISC_SVC_WAIT; bleCtsSvcStart = bleCtsSvcEnd = 0; portEXIT_CRITICAL(&bleMux);
      ble_gattc_exchange_mtu(ch, nullptr, nullptr);
      if (ble_gattc_disc_svc_by_uuid(ch, &u.u, onBleCtsSvcCb, nullptr) != 0) {
        if (bleCtsAttempt < 10) { bleCtsAttempt++; setCtsState(CTS_DISC_SVC, 2000UL); }
        else { bleCtsLogNoCts = true; setCtsState(CTS_DISC_BAT_SVC, 60UL); }
      }
    } else if (st == CTS_DISC_CHR) {
      portENTER_CRITICAL(&bleMux); bleCtsState = CTS_DISC_CHR_WAIT; bleCtsTimeHandle = bleCtsLocalHandle = 0; portEXIT_CRITICAL(&bleMux);
      if (ble_gattc_disc_all_chrs(ch, bleCtsSvcStart, bleCtsSvcEnd, onBleCtsChrCb, nullptr) != 0) setCtsState(CTS_DISC_BAT_SVC, 40UL);
    } else if (st == CTS_READ_LOCAL) {
      setCtsState(CTS_READ_LOCAL_WAIT);
      if (ble_gattc_read(ch, bleCtsLocalHandle, onBleCtsLocalReadCb, nullptr) != 0) setCtsState(CTS_READ_TIME, 40UL);
    } else if (st == CTS_READ_TIME) {
      setCtsState(CTS_READ_TIME_WAIT);
      if (ble_gattc_read(ch, bleCtsTimeHandle, onBleCtsTimeReadCb, nullptr) != 0) setCtsState(CTS_DISC_BAT_SVC, 40UL);
    } else if (st == CTS_DISC_BAT_SVC) {
      static const ble_uuid16_t u = BLE_UUID16_INIT(0x180F);
      portENTER_CRITICAL(&bleMux); bleCtsState = CTS_DISC_BAT_SVC_WAIT; bleBatSvcStart = bleBatSvcEnd = 0; portEXIT_CRITICAL(&bleMux);
      if (ble_gattc_disc_svc_by_uuid(ch, &u.u, onBleBatSvcCb, nullptr) != 0) setCtsState(CTS_DONE);
    } else if (st == CTS_DISC_BAT_CHR) {
      portENTER_CRITICAL(&bleMux); bleCtsState = CTS_DISC_BAT_CHR_WAIT; blePeerBatHandle = 0; portEXIT_CRITICAL(&bleMux);
      if (ble_gattc_disc_all_chrs(ch, bleBatSvcStart, bleBatSvcEnd, onBleBatChrCb, nullptr) != 0) setCtsState(CTS_DONE);
    } else if (st == CTS_READ_BAT) {
      setCtsState(CTS_READ_BAT_WAIT);
      if (ble_gattc_read(ch, blePeerBatHandle, onBleBatReadCb, nullptr) != 0) setCtsState(CTS_DONE);
    }
  }
}

void setup() {
  Serial.begin(115200);
  delay(300);
  randomSeed(esp_random());
  loadPrefsAndClock();
  initInputPin();

  u8g2.setBusClock(400000);
  u8g2.begin();
  u8g2.setContrast(activeContrast());
  playBootSplash();

  rtcAvailable = rtc.begin();
  if (rtcAvailable) {
    if (rtc.lostPower()) rtc.adjust(cachedNow);
    else { DateTime hw = rtc.now(); if (hw.year() >= 2024) setLocalEpoch(hw.unixtime(), "RTC", true, true); }
  }
  batteryAvailable = maxlipo.begin();
  setupConnectivity();
  updateSensors();
  lastActivityMs = millis();
  Serial.println(F("DINO KEY V1 READY!"));
}

void loop() {
  if (Serial.available()) executeSyncCommand(Serial.readStringUntil('\n'), "USB");
  processBleQueue();
  dnsServer.processNextRequest();
  server.handleClient();
  wifiAndNtpTick();

  unsigned long now = millis();
  InputEvent ev = readInput();
  if (ev != EVT_NONE) {
    lastActivityMs = now;
    if (currentMode == MODE_SLEEP) {
      currentMode = previousMode; u8g2.setContrast(activeContrast());
    } else if (currentMode == MODE_DINO && dinoPlaying) {
      if (ev == EVT_PRESS_DOWN) dinoJump();
      else if (ev == EVT_LONG_PRESS) { dinoPlaying = false; previousMode = currentMode; currentMode = MODE_SLEEP; u8g2.setContrast(15); }
    } else if (!(currentMode == MODE_DINO && (now - dinoOverAt < 800))) {
      if (ev == EVT_SINGLE_CLICK) currentMode = (ScreenMode)((currentMode + 1) % 8);
      else if (ev == EVT_DOUBLE_CLICK) {
        if (currentMode == MODE_DINO) dinoStart();
        else if (currentMode == MODE_CONNECT) { wifiActiveSlot = 0; wifiState = STA_IDLE; }
        else if (currentMode == MODE_STOPWATCH) toggleStopwatch();
        else if (currentMode == MODE_BRIGHTNESS) setBrightnessLevel((brightnessLevel % 5) + 1, true);
        else if (currentMode == MODE_HOME || currentMode == MODE_FULL_FACE) faceIdx = (faceIdx + 1) % 20;
      } else if (ev == EVT_LONG_PRESS) {
        if (currentMode == MODE_STOPWATCH && (swRunning || swAccumMs > 0)) resetStopwatch();
        else { previousMode = currentMode; currentMode = MODE_SLEEP; u8g2.setContrast(15); }
      }
    }
  }

  if (currentMode == MODE_DINO && dinoPlaying) lastActivityMs = now;
  else if (currentMode != MODE_SLEEP && (now - lastActivityMs >= AUTO_SLEEP_MS)) {
    previousMode = currentMode; currentMode = MODE_SLEEP; u8g2.setContrast(15);
  }

  updateSensors();
  if (currentMode == MODE_HOME || currentMode == MODE_FULL_FACE) {
    if (!isBlinking && now >= nextBlinkMs && faceIdx != FACE_SLEEPY_IDX && faceIdx != FACE_SLEEPING_IDX) { isBlinking = true; blinkEndMs = now + 140; }
    if (isBlinking && now >= blinkEndMs) { isBlinking = false; nextBlinkMs = now + random(2500, 5500); }
  } else isBlinking = false;

  if (currentMode == MODE_DINO && dinoPlaying) dinoUpdate();

  if (now - lastFrameMs >= ((currentMode == MODE_SLEEP) ? 1000UL : 20UL)) {
    lastFrameMs = now;
    u8g2.clearBuffer(); u8g2.setDrawColor(1);
    switch (currentMode) {
      case MODE_HOME:       renderHome(); break;
      case MODE_CLOCK:      renderClock(); break;
      case MODE_STOPWATCH:  renderStopwatch(); break;
      case MODE_BATTERY:    renderBattery(); break;
      case MODE_DINO:       renderDino(); break;
      case MODE_FULL_FACE:  renderFullFace(); break;
      case MODE_CONNECT:    renderConnect(); break;
      case MODE_BRIGHTNESS: renderBrightness(); break;
      case MODE_SLEEP:      renderSleep(); break;
    }
    u8g2.sendBuffer();
  }
}
